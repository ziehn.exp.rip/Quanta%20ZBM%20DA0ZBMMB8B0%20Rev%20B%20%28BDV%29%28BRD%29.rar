# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLAN_CLKREQ_ODL: length 167.8
  TOP w0.089: 100.47,55.06 100.97,55.06 101.43,55.06 101.52,55.06 101.62,54.96 101.86,54.96 102.31,55.41 U1JSL.CL41
  TOP w0.109: v2(99.02,54.76) 99.41,55.16 100.38,55.16 100.47,55.06
  IN2 w0.097: v2(34.85,25.08) 35.17,25.08 36.13,26.04 41.58,26.04 47.99,32.45 51.68,32.45 52.31,31.82 60.73,31.82 71.83,20.72 78.17,20.72 80.2,18.7 83.37,18.7 85.84,21.17 90.7,21.17 93.67,18.2 102.09,18.2 102.76,18.87 104.63,18.87 105.7,19.94 107.9,19.94 108.31,19.53 109.16,19.53 109.42,19.78 v2(110.11,19.78) ; v2(99.02,54.76) 98.54,55.24 97.62,55.24 96.54,54.16 96.54,52.39 96.67,52.26 96.67,50.1 96.14,49.58 93.94,49.58 93.83,49.46 90.95,49.46 90.06,50.35 87.27,50.35 82.47,45.56 82.47,31.09 87.63,25.93 87.63,25.33 v2(87.72,25.23)
  BOTTOM w0.114: R111.2 34.76,25.17 v2(34.85,25.08) U4100.30 ; v2(87.72,25.23) 88.22,25.73 104.15,25.73 105.36,26.93 107.03,26.93 110.46,23.5 110.46,21.23 110.11,20.87 v2(110.11,19.78)
WLAN_DISABLE_L: length 126.7
  TOP w0.089: v1(104.12,65.01) 103.82,64.7 U1JSL.CH21
  IN4 w0.089: v1(104.12,65.01) 104.15,65.01 104.54,64.62 104.54,63.94 103.78,63.18 100.83,63.18 98.33,60.67 98.05,60.67 97.2,59.83 97.2,59.45 95.6,57.85 93.72,57.85 88.41,52.54 88.41,51.37 84.87,47.83 84.87,36.24 84.99,36.12 84.99,29.35 86.93,27.41 86.93,25.83 v2(86.34,25.23)
  BOTTOM w0.114: v2(86.34,25.23) 85.92,25.66 85.47,25.66 85.2,25.38 85.2,25.08 84.81,24.69 82.09,24.69 81.59,25.18 77.63,25.18 74.8,28.01 74.8,33.26 72.38,35.68 71.57,35.68 67.36,31.47 58.76,31.47 57.02,33.21 49.4,33.21 44.72,28.53 38.6,28.53 37.64,29.49 33.63,29.49 31.88,27.74 31.88,24.22 32,24.09 R116.2 32.5,24.09 32.75,23.84 32.75,23.45 32.95,23.25 U4100.28
WLAN_INT_L: length 2.1
  TOP w0.109: TP110.1 33.02,13.25 v2(32.17,13.25)
  BOTTOM w0.114: U4100.8 v2(32.17,13.25)
WLAN_PCIE_WAKE_ODL: length 124.9
  TOP w0.089: v1(104.9,66.76) 105.14,66.53 U1JSL.CE17
  IN4 w0.089: v1(104.9,66.76) 104.9,66.41 103.92,65.43 103.36,65.43 102.46,64.53 102.46,63.64 102.25,63.43 100.82,63.43 98.25,60.86 97.97,60.86 96.99,59.89 96.99,59.57 96.22,58.8 94.4,58.8 88.22,52.62 88.22,51.45 84.68,47.91 84.68,36.05 84.8,35.93 84.8,29.24 86.73,27.31 86.73,25.92 86.54,25.73 86.24,25.73 v2(85.74,25.23)
  BOTTOM w0.114: v2(85.74,25.23) 84.95,24.44 81.98,24.44 81.49,24.93 77.52,24.93 74.55,27.91 74.55,33.16 72.28,35.43 71.68,35.43 67.46,31.22 58.66,31.22 56.92,32.96 49.5,32.96 44.82,28.28 38.51,28.28 37.54,29.25 33.98,29.25 33.13,28.4 33.13,26.03 33.41,25.74 R112.1 34,25.33 34.35,24.98 U4100.29
WLAN_PE_PLT_RST_L: length 11
  BOTTOM w0.114: R27312.1 41.87,27.11 41.57,27.41 37.68,27.41 37.35,27.75 U16.4 36.87,27.72 36.87,26.29 36.62,26.04 35.97,26.04 35.68,25.74 R120.1 35.52,25.46 35.35,25.29 U4100.31
WLAN_PERST_L: length 336.5
  TOP w0.089: U1JSL.CJ17 103.16,66.52 102.66,67.02 102.66,67.91 102.89,68.13 102.89,68.39 103.14,68.64 103.52,68.64 v1(103.57,68.59)
  IN2 w0.097: v2(174.6,76.05) 173.99,75.43 171.6,75.43 170.8,76.23 169.12,76.23 168.43,76.93 162.85,76.93 160.38,79.4 147.43,79.4 145.15,77.13 145.15,75.09 143.02,72.96 130.73,72.96 129.86,72.1 108.83,72.1 108.06,71.32 108.06,68.95 107.75,68.64 107.19,68.64 106.84,69 103.88,69 103.57,68.69 v1(103.57,68.59)
  IN4 w0.089: v2(174.6,76.05) 174.95,75.7 181.65,75.7 194.17,63.19 194.17,25.03 189.36,20.22 182.37,20.22 178.03,15.88 167.81,15.88 164.08,12.15 110.51,12.15 109.88,12.79 107.52,12.79 106.99,12.25 104.64,12.25 v2(104.15,12.75)
  BOTTOM w0.114: U16.6 35.08,27.75 R109.1 35.04,27.43 34.92,27.31 34.32,27.31 34.22,27.41 34.22,28.5 34.72,29 37.09,29 38.08,28.01 44.97,28.01 49.6,32.64 56.82,32.64 58.48,30.97 70.64,30.97 70.93,30.68 70.93,29.73 73.36,27.3 74.75,27.3 77.43,24.62 81.29,24.62 81.77,24.14 87.33,24.14 88.62,25.43 98.42,25.43 102.39,21.47 104.9,21.47 106.92,19.45 106.92,18.02 107.66,17.28 107.66,16.43 104.15,12.92 v2(104.15,12.75)
WLAN_REFCLK0: length 2.6
  TOP w0.109: TP4.1 43.73,15.33 v2(43.71,15.3)
  BOTTOM w0.114: U4100.A44 43.26,16.75 43.54,16.47 43.54,15.79 43.71,15.63 v2(43.71,15.3)
WLAN_SCL: length 2.5
  TOP w0.109: TP111.1 32.91,14.67 v2(32.15,13.9)
  BOTTOM w0.114: v2(32.15,13.9) 32.3,13.75 U4100.9
WLAN_SDA: length 3.2
  TOP w0.109: v2(32.15,14.54) 33.04,15.43 TP112.1
  BOTTOM w0.114: v2(32.15,14.54) 32.44,14.25 U4100.10
WLAN_SUSCLK: length 112.5
  TOP w0.089: R386.2 99.56,45.11 99.16,45.11 98.87,45.4 R387.2 v1(99.4,45.49)
  IN1 w0.097: v1(99.4,45.49) 98.1,44.19 91.16,44.19 90.83,43.86 89.81,43.86 88.54,42.59 88.54,28.71 86.24,26.42 v2(86.24,26.12)
  IN4 w0.089: v2(31.73,23.55) 32.54,22.74 v2(34.29,22.74)
  BOTTOM w0.109: U4100.A25 34.3,22.75 v2(34.29,22.74) ; R27311.2 31.75,23.53 v2(31.73,23.55) 31.38,23.9 31.38,28.13 33.24,29.99 38.19,29.99 39.16,29.02 44.16,29.02 48.99,33.85 57.22,33.85 59.09,31.98 67.08,31.98 71.97,36.87 77.56,36.87 79.21,38.51 82.57,38.51 85.05,36.03 85.05,32.17 85.35,31.87 85.77,31.87 86.24,31.4 v2(86.24,26.12)
WLAN_SUSCLK_R: length 11.9
  TOP w0.089: U1JSL.BY49 107.43,51.54 107.35,51.37 107.29,51.24 107.29,51.05 107.42,50.84 107.42,50.29 107.47,50.24 107.47,48.95 104.32,45.8 103.65,45.8 102.77,44.92 v4(101.44,44.92) 101.17,45.19 100.96,45.19 100.91,45.25 100.55,45.25 100.39,45.4 R386.1
WWAN_EN: length 5.4
  TOP w0.089: U1JSL.CM33 101.57,59.25 101.41,59.41 100.9,59.41 100.8,59.51 100.5,59.51 100.42,59.44 99.47,59.44 98.74,60.17 97.57,60.17 97.2,59.8 TP101.1
WWAN_PERST: length 4.6
  TOP w0.089: TP100.1 97.43,62.88 97.71,62.6 99.4,62.6 99.84,63.03 100.8,63.03 U1JSL.CN24
WWAN_RST_L: length 1.2
  TOP w0.089: U1JSL.CC21 105.5,64.29 v1(105.5,64.15)
  BOTTOM w0.089: v1(105.5,64.15) 105.5,64.12 TP102.1
WWAN_SAR_DETECT_ODL: length 3.3
  TOP w0.109: U1JSL.CR41 100.6,55.4 99.02,55.4 v2(98.39,54.76)
  BOTTOM w0.114: TP99.1 98.44,54.71 v2(98.39,54.76)
WWAN_WDISABLE_L: length 1.4
  TOP w0.089: v2(103.5,66.74) 103.82,66.42 U1JSL.CH17
  BOTTOM w0.089: v2(103.5,66.74) 103.52,66.74 104.11,66.15 TP98.1
WWAN_WLAN_COEX1: length 1.8
  TOP w0.089: R367.2 96.06,64.75 95.72,65.09 95.01,65.09 TP103.1
WWAN_WLAN_COEX2: length 0.9
  TOP w0.089: TP104.1 94.71,64.66 R366.2
WWAN_WLAN_COEX3: length 0.7
  TOP w0.109: R369.2 TP105.1
XTAL_PCH_38P4M_IN: length 9.1
  TOP w0.109: Y4102.1 113.03,79.72 112.64,79.72 112.51,79.59 112.51,79.26 112.64,79.13 113.63,79.13 113.73,79.04 C4102.1 113.73,78.12 113.8,78.05 113.8,77.71 113.4,77.31 R4102.2 113.4,76.69 v4(113.15,76.44) 113.15,76.04 113.4,75.79 113.4,74.72 114.25,73.87 114.25,73.32 U1JSL.BE1
XTAL_PCH_38P4M_OUT: length 9.8
  TOP w0.109: Y4102.3 114.06,80.45 114.06,79.51 114.29,79.29 C4101.1 114.29,78.29 114.22,78.22 v4(114.22,77.94) 114.22,77.7 113.85,77.33 R4102.1 113.85,77.09 113.63,76.87 113.63,74.8 114.47,73.96 114.47,73.5 114.52,73.46 114.52,73.15 114.24,72.88 114.24,72.48 U1JSL.BE3
XTAL_RTC_32K_IN: length 20.2
  TOP w0.089: 102.07,47.59 102.24,47.59 102.78,47.04 103.8,47.04 105.64,48.88 105.64,50.28 105.54,50.38 105.54,50.87 105.57,50.89 105.57,51.38 105.31,51.64 U1JSL.CE49
  TOP w0.109: 102.07,47.59 102.04,47.61 94.84,47.61 v4(94.64,47.82) 94.4,48.06 94.09,48.06 93.08,49.06 R4101.1 C4104.1 92.52,50.14 91.93,50.72 Y4101.2
XTAL_RTC_32K_OUT: length 19.6
  TOP w0.089: 102.13,47.98 102.88,47.22 103.73,47.22 105.45,48.94 105.45,50.22 105.37,50.3 105.37,51.03 105.39,51.06 105.39,51.29 105.04,51.63 105.04,51.78 104.95,51.87 104.95,51.97 U1JSL.CE48
  TOP w0.109: 102.13,47.98 95.31,47.98 94.7,48.59 94.29,48.59 v4(93.95,48.93) 93.53,49.35 R4101.2 C4103.1 94.1,49.9 94.43,50.23 Y4101.1
N17510052: length 2.1
  TOP w0.109: Q15.3 173.21,22.82 173.8,22.22 D21.1
N17589030: length 1.8
  TOP w0.109: R8.2 91.34,75.8 v4(91.26,75.72)
  TOP w0.254: R8.2 91.94,75.27 91.99,75.22 C3609.1
N17621727: length 1.8
  BOTTOM w0.114: D9.2 181.29,24.86 181.46,24.69 Q6.3
N17740383:
  vias: v4(176.76,56.04)
N17740385: length 0.9
  TOP w0.109: v4(174.5,56.82) 174.5,55.97 174.56,55.9
N17740537: length 2.6
  TOP w0.109: R429.2 178.08,62.42 178.6,62.42 178.61,62.42 v4(179.09,62.42)
  TOP w0.203: R430.1 R429.2
N17740570: length 27.6
  TOP w0.109: R268.1 164.39,67.33 v2(164.41,67.35)
  BOTTOM w0.114: v2(164.41,67.35) 164.75,67 172.91,67 174.32,65.59 v4(174.6,65.59) 174.82,65.37 175.82,65.37 180.59,60.61 181.71,60.61 184.13,58.18 184.13,55.42 184.27,55.29 R270.1
N17740572: length 2.4
  BOTTOM w0.114: R270.2 184.27,54.08 v4(183.95,53.76) 183.95,53.46 183.83,53.34 R269.2 R275.1
N17740737: length 2.7
  BOTTOM w0.114: 181.37,53.64 181.37,53.64 180.89,54.11 v4(180.21,54.11) ; 181.37,53.64 C232.2 ; 181.37,53.64 R362.2
N17740831: length 3.1
  TOP w0.109: v2(182.67,55.36) 182.52,55.21 182.52,55.05 182.09,54.62 U10.15
  BOTTOM w0.114: C305.2 R426.1 182.08,55.39 182.11,55.36 v2(182.67,55.36)
N17740886: length 5.7
  TOP w0.109: U10.16 182.08,55.02 182.23,55.17 182.23,56.61 182.08,56.75 v2(182.08,56.78)
  BOTTOM w0.114: C305.1 R426.2 182.05,56.75 v2(182.08,56.78) 182.08,57.39 R428.1 181.94,57.52 C405.2
N17740890: length 0.7
  TOP w0.109: R135.2 R138.1
N17740892: length 2.5
  TOP w0.109: R143.1 R232.1 180.68,48.26 180.56,48.14 v4(180.56,46.8)
N17740894: length 1.9
  TOP w0.109: R235.2 R236.1 179.91,48.26 179.75,48.09 179.75,47.81 v4(179.42,47.48)
N17740896: length 2.6
  BOTTOM w0.114: R265.1 181.09,57.27 180.4,57.96 R264.2 v4(181.08,58.7)
N17742434:
  vias: v4(170.97,67.71)
N17742859: length 2.9
  TOP w0.109: R27221.2 v4(160.64,52.74)
  TOP w0.381: R27221.2 161.89,52.22 162.22,51.89 C27230.1
N17743042:
  vias: v4(156.84,80.66)
N17743283: length 3.8
  TOP w0.203: U38.5 162.76,77.76 163.04,78.05 163.04,78.34 162.53,78.85 162.4,78.85
  TOP w0.381: R459.1 161.64,79.5 161.69,79.46 v4(161.69,78.67) 161.87,78.85 162.4,78.85
N17743285: length 3.4
  TOP w0.109: R459.2 160.86,80.01 v4(160.04,80.83)
  TOP w0.381: C364.1 160.89,77.96 160.89,79.61 R459.2
N17743387: length 2.7
  TOP w0.109: U38.4 163.16,77.73 163.39,77.96 163.39,78.69 163.28,78.8 v4(163.26,78.8) 163.26,78.85 162.65,79.47 R455.2
N17743475: length 2.9
  TOP w0.114: U38.14 164.7,74.97 164.81,74.86 v4(165.25,74.86) 165.47,74.64 165.47,73.95 165.18,73.66 165.06,73.66 164.83,73.43 R458.1
N17745848:
  vias: v4(52.6,47.23)
N17746077:
  vias: v4(53.08,57.26)
N17746099:
  vias: v4(52.45,60.64)
N17746131: length 2.2
  TOP w0.178: 51.83,56.7 51.51,56.7 51.31,56.91 U21.10
  TOP w0.203: 51.83,56.7 51.96,56.7 52.22,56.45 52.27,56.4 52.27,56.27 v2(52.34,56.2)
  BOTTOM w0.381: R435.1 v2(52.34,56.2)
N17746133: length 1
  BOTTOM w0.381: R435.2 C320.1
N17746351: length 2.6
  BOTTOM w0.114: v4(68.47,55.48) 67.52,55.48 R442.1
  BOTTOM w0.508: C333.2 R442.1
N17746361: length 4.2
  TOP w0.203: 53.03,58.79 52.81,58.57 U21.13
  TOP w0.762: 53.03,58.79 54.42,58.79 55.11,58.1 55.77,58.1
N17746433: length 2.3
  TOP w0.109: U21.3 48.2,58.57 v4(47.96,58.81) 48.12,58.97 U21.2
N17746595: length 1.9
  TOP w0.109: R438.1 46.66,54.87 46.68,54.9 v4(46.68,55.33) 46.99,55.64 C322.2
N17746603: length 2.3
  TOP w0.109: C332.2 48.55,54.29 49.7,54.29 50.26,54.85 R440.1
N17746864: length 1.7
  TOP w0.508: R244.1 185.13,34.44 v4(185.09,34.49)
N17747083:
  vias: v4(61.36,34.61)
N17747159: length 2.3
  TOP w0.254: C284.1 62.37,36.1 v4(61.99,35.72) 61.49,36.23 U33.2
N17747309:
  vias: v4(61.49,38.54)
N17747334: length 2.3
  TOP w0.109: v4(184.55,41.79) 184.74,41.6 R441.1
  TOP w0.203: U22.9 184.59,41.07 R441.1
N17747362: length 1.5
  TOP w0.254: C285.1 61.92,36.73 U33.3
N17747473: length 2.3
  TOP w0.203: U22.18 179.24,40.67
  TOP w0.381: R377.1 178.25,41.26 178.84,40.67 179.04,40.67 v4(179.09,40.62) 179.14,40.67 179.24,40.67
N17747475: length 1.9
  TOP w0.109: C366.1 178.26,42.29 v4(178.31,42.24)
  TOP w0.381: R377.2 177.5,41.3 C366.1
N17747804: length 2.5
  TOP w0.109: R437.2 181.37,44.36 v4(181.37,43.83) 181.68,43.52 181.68,43.44 181.78,43.34 181.78,42.97 181.83,42.93 U22.13
N17747956: length 1.6
  TOP w0.109: C1001.1 182.31,38.17 182.23,38.25 U22.4
N17749264:
  vias: v4(37.91,35.22)
N17749266:
  vias: v4(36.44,37.91)
N17749368: length 4
  TOP w0.203: U31.6 42.09,33.49 42.35,33.75 42.35,34.65 43.43,35.72 R319.2 R463.2
N17749418: length 2.7
  TOP w0.203: R263.1 41.67,36 41.52,35.85 v4(41.22,35.85) 41.04,35.85 40.68,35.5 40.68,35.01 40.55,34.88 U31.9
N17749420: length 1.5
  TOP w0.203: C258.1 42.25,37.61 42,37.36 R263.2
N17749576:
  vias: v4(69.1,25.63)
N17749625: length 2.8
  TOP w0.254: U32.7 76.88,24.93 76.9,24.95
  TOP w0.508: 76.9,24.95 R347.1
N17749627: length 1.3
  TOP w0.508: C266.1 80.04,25.12 R347.2
N17749695: length 4
  TOP w0.254: R447.2 C353.1 72.15,27.62 71.7,27.17 71.7,26.35 72.13,25.93 U32.2
N17750770:
  vias: v4(37.41,45.25)
N17750772: length 1.5
  TOP w0.508: C255.1 34.97,47.03 35.33,46.66 R346.2
N17750890: length 2.8
  TOP w0.203: R464.2 42.03,44.48 42.06,44.45 42.06,43.63 41.75,43.32 41.75,42.81 41.52,42.58 U30.6
N17750944: length 1.8
  TOP w0.203: U30.12 38.51,43.86 38.19,44.19 R262.1
N17750946: length 1.6
  TOP w0.203: C257.1 38.19,47.06 v4(38.19,46.39) R262.2
N17751357: length 1.7
  TOP w0.109: D28.2 85.48,12.36 C289.2 84.52,12.35 R378.1
N17753294: length 2.2
  TOP w0.109: v4(175.15,28.39) U36.3
  TOP w0.203: U36.3 175.98,29.14 176.07,29.23 R303.2
N17753848: length 1.9
  TOP w0.109: C296.1 37.43,54.03 37.33,53.94 37.33,53.68 37.31,53.66 v4(37.31,53.58) 37.31,53.17 37.33,53.14 37.33,53.14 37.41,53.06 U23.12
N17754636:
  vias: v4(83.53,55.79)
N17756404: length 9.6
  BOTTOM w0.114: R91343.2 91.99,21.12 92.24,20.87 R255.2 ; R257.1 R255.2 ; R255.2 93.34,20.87 93.68,21.21 Q14.2 93.68,22.09 93.45,22.32 C28022.2 ; C28022.2 93.92,23.23 94.15,23.46 D2744.1 ; C28022.2 93.45,23.72 93.14,24.03 C28023.2
N17788307: length 5.6
  TOP w0.089: v4(97.02,61.5) 97.29,61.23 97.3,61.23 97.55,60.98 98.76,60.98 99.33,61.55 100.24,61.55 100.42,61.37 100.74,61.37 101.04,61.55 U1JSL.CN27
  TOP w0.109: v4(97.02,61.5) 96.92,61.61 R380.2
N17788317: length 8.4
  TOP w0.089: 96.68,59.67 96.93,59.42 97.32,59.42 97.48,59.57 97.48,59.63 97.48,59.63 97.48,59.64 97.48,59.76 97.69,59.97 97.72,59.99 98.66,59.99 99.39,59.26 100.63,59.26 U1JSL.CR33 ; v4(93.46,59.09) 93.85,59.09 94,58.94 94.28,58.94 94.58,59.23 R381.2
  TOP w0.109: 96.68,59.67 96.63,59.72 95.76,59.72 95.68,59.63 95.51,59.63 95.41,59.54 94.79,59.54 R381.2
N17788327: length 8.3
  TOP w0.089: R91323.1 95.09,60.21 95.27,60.39 95.78,60.39 95.85,60.46 96.18,60.46 96.43,60.21 R382.2 96.74,60.11 96.87,60.23 97.25,60.23 97.36,60.35 99.04,60.35 99.16,60.47 100.18,60.47 100.58,60.07 100.81,60.07 100.98,60.17 101.3,60.17 101.49,60.26 101.68,60.46 101.92,60.46 102.1,60.28 U1JSL.CL30
N17788329: length 7.9
  TOP w0.089: 97.53,61.28 97.65,61.15 98.68,61.15 99.26,61.73 100.57,61.73 U1JSL.CR27 ; R27310.1 94.13,62.36 94.58,61.91 R383.2
  TOP w0.109: R383.2 94.65,61.86 95.64,61.86 95.77,61.99 97.15,61.99 97.43,61.71 97.43,61.38 97.53,61.28
N17801684: length 5
  TOP w0.089: U1JSL.CH30 v1(103.46,59.73)
  BOTTOM w0.109: R331.2 100.44,58.19 v4(100.6,58.35) 100.89,58.65 101.98,58.65 102.16,58.82 102.16,59.03 102.71,59.58 103.31,59.58 v1(103.46,59.73)
N17801691: length 7.1
  TOP w0.089: U1JSL.CC28 105.43,60.8 v2(105.43,60.77)
  BOTTOM w0.109: R332.2 100.95,61.95 101.52,62.52 101.98,62.52 v4(102.38,62.12) 104.89,62.12 105.43,61.58 v2(105.43,60.77)
N17813996: length 2.2
  TOP w0.089: U1JSL.CB30 106.46,60.15 v2(106.13,59.82)
  BOTTOM w0.109: v2(106.13,59.82) 105.65,59.34 105.32,59.34 105.02,59.03 R333.2
N17814026: length 7.3
  TOP w0.089: U1JSL.CF30 v1(104.13,59.73)
  BOTTOM w0.109: v1(104.13,59.73) 103.68,59.28 102.75,59.28 102.46,58.98 102.46,58.71 101.97,58.23 101.06,58.23 100.22,57.39 100.02,57.39 v4(99.71,57.08) 99.52,57.27 R334.2
N17814069: length 5.9
  TOP w0.089: U1JSL.CL14 102.19,67.72 101.68,67.72 101.4,67.44 101.03,67.44 100.79,67.3 100.59,67.3 100.47,67.42 98.95,67.42 98.67,67.7 98.41,67.7
  TOP w0.109: R385.2 98.41,67.7
N17814071: length 3.4
  TOP w0.089: v1(103.52,64.15) 103.82,63.85 U1JSL.CH23
  BOTTOM w0.089: v1(103.52,64.15) 103.42,64.25 103.21,64.25 102.96,64.5 102.56,64.5
  BOTTOM w0.109: R335.2 101.13,64.3 101.36,64.07 102.12,64.07 v4(102.25,64.2) 102.56,64.5
N17814073: length 6.3
  TOP w0.089: v2(106.13,60.72) 106.46,61.05 U1JSL.CB28
  BOTTOM w0.109: R336.2 v4(101.74,59.12) 102.48,59.86 103.08,59.86 103.32,60.1 104.33,60.1 104.46,60.22 105.63,60.22 v2(106.13,60.72)
N17814084: length 2.5
  TOP w0.089: U1JSL.CC30 105.8,60.15 v2(105.47,59.82)
  BOTTOM w0.109: R337.2 104.56,59.37 104.92,59.37 105.37,59.82 v2(105.47,59.82)
N17817068: length 4.4
  TOP w0.089: 97.2,63.74 97.66,63.74 97.95,64.03 99.81,64.03 99.89,64.12 100.6,64.12 U1JSL.CR22
  TOP w0.109: 97.2,63.74 96.91,63.74 96.75,63.89 R369.1
N17817143: length 7
  TOP w0.089: 97.01,64.21 97.04,64.18 v4(97.25,64.18) 97.64,64.18 97.66,64.21 99.73,64.21 99.82,64.29 100.43,64.29 100.49,64.35 100.74,64.35 100.92,64.24 101.05,64.22 101.22,64.26 101.39,64.24 101.63,64.08 U1JSL.CM22
  TOP w0.109: 97.01,64.21 96.98,64.21 96.92,64.28 95.62,64.28 95.53,64.36 95.44,64.36 95.24,64.57 R366.1
N17817150: length 5.7
  TOP w0.089: U1JSL.CM20 101.66,65 101.56,64.91 101.44,64.86 101.41,64.82 101.03,64.82 100.84,64.71 100.52,64.71 100.45,64.78 99.95,64.78 99.57,64.39 97.85,64.39 97.66,64.58 97.12,64.58
  TOP w0.109: 97.12,64.58 96.71,64.58 96.64,64.66 R367.1
N17996760: length 2.4
  TOP w0.109: R91329.2 21.95,19.02 21.52,19.45 21.11,19.45 20.85,19.72 U2.14
N17996780: length 1.3
  TOP w0.109: U2.10 18.85,19.44 18.81,19.41 R91358.2
N17997033: length 3
  TOP w0.109: U2.8 17.5,20.39 17.18,20.07 R91360.2 17.34,18.73 17.34,18.37 R91331.2
N17997051: length 3
  TOP w0.109: U2.9 17.67,20.15 17.47,19.95 17.47,19.46 17.73,19.21 R91359.2 17.63,18.79 17.63,18.42 17.8,18.24 R91330.2
N17997104: length 1.7
  TOP w0.109: U2.28 20.35,26.17 19.91,26.6 C137.1
N17997107: length 1.6
  TOP w0.109: C138.1 23.34,22.95 23.29,23 U2.21
N17998507: length 1.4
  TOP w0.109: C145.1 24.2,16.87 24.53,16.54 U4.28
N17998525: length 1.5
  TOP w0.109: C146.1 27.88,13.17 27.47,13.58 U4.21
N17999533: length 1.6
  TOP w0.109: R91332.2 25.24,9.89 25.03,10.1 U4.14
N17999580: length 2.9
  TOP w0.109: R91362.2 R91333.2 20.69,10.35 20.79,10.44 21.04,10.44 21.33,10.73 U4.9
N17999587: length 3.3
  TOP w0.109: U4.8 21.68,11.16 21.54,11.02 21.21,11.02 20.92,10.73 20.67,10.73 20.13,10.19 R91334.2 R91363.2
N18000201: length 2.9
  TOP w0.109: U3.4 20.74,41.99 21.71,42.96 21.71,43.62 TP3.1
N18000280: length 4.3
  TOP w0.109: v4(18.36,32.37) 18.57,32.58 C82.2 18.99,33.63 18.99,35.11 19.54,35.65 U3.24
N18000283: length 5
  TOP w0.109: U3.21 18.33,35.6 17.37,34.63 17.37,33.63 C82.1 17.79,32.64 17.52,32.37 v4(17.09,32.37)
N18000315: length 2.2
  TOP w0.109: U3.23 19.14,35.64 18.57,35.07 C83.1
N18000324: length 2.4
  TOP w0.109: U3.22 18.74,35.62 17.79,34.67 C83.2
N18000375: length 4.6
  TOP w0.109: C79.1 22.37,44.82 22.37,43.65 22.09,43.37 22.09,42.94 21.14,41.98 U3.3
N18000412: length 3.2
  TOP w0.109: C76.1 16.15,41.84 16.55,41.43 16.55,40.27 17,39.82 U3.13
N18000432: length 2.2
  TOP w0.203: v2(16.4,38.22) U3.17
  BOTTOM w0.381: C73.1 16.86,38.55 16.53,38.22 v2(16.4,38.22)
N18000455: length 2.4
  TOP w0.203: U3.25 19.94,35.59 19.79,35.44 19.79,35.28 v4(19.45,34.94)
  TOP w0.508: v4(19.45,34.94) 19.58,34.81 C70.1
N18000486: length 2.5
  TOP w0.203: 18.74,42.05 U3.9
  TOP w0.254: 18.74,42.05 17.67,43.11 C69.1
N18000635: length 2.3
  TOP w0.203: v4(20.72,34.96) 20.72,35.18 20.33,35.56 U3.26
  TOP w0.508: v4(20.72,34.96) 20.72,34.23 C80.1
N18002909: length 5.4
  TOP w0.109: R91336.2 23.16,32.32 22.93,32.32 21.32,33.93 21.32,34.57 21.18,34.71 21.18,35.29 20.74,35.73 U3.27
N18002922: length 4.9
  TOP w0.109: U3.28 21.14,35.74 21.46,35.41 21.46,34.83 21.61,34.69 21.61,34.05 23.05,32.61 23.16,32.61 R91335.2
N18004865: length 2.8
  TOP w0.109: R88.1 16.78,41.77 v4(16.96,41.59) 16.81,41.44 16.81,40.42 17.01,40.22 U3.12
N18155934: length 1.9
  TOP w0.097: U8.1 37.32,69.89 37.21,69.78 36.94,69.78 36.84,69.88 36.25,69.88 36.08,70.04 R218.1
N18155937: length 2
  TOP w0.097: U8.2 37.35,69.49 37.24,69.59 36.86,69.59 36.77,69.69 36.21,69.69 36.08,69.57 R219.1
N18158439: length 4.4
  TOP w0.109: v2(36.17,66.1) 36.77,66.7 38.18,66.7 38.44,66.95 U8.6
  BOTTOM w0.114: R91348.2 35.73,66.67 35.83,66.58 R91345.1 v2(36.17,66.1)
N18158454: length 8.1
  TOP w0.109: v2(36.8,66.13) 37.09,66.42 38.49,66.42 38.84,66.77 U8.7
  BOTTOM w0.114: v2(36.8,66.13) 37.51,66.84 37.51,68.81 37.19,69.12 R91346.1 R91347.2
N18182049: length 2.8
  TOP w0.097: C161.1 31.06,67.95 30.99,68.02 30.99,68.26 30.68,68.57 30.45,68.57 30.31,68.71 30.31,68.95 30.43,69.07 Q12.3
N18182083: length 2.8
  TOP w0.097: C162.1 30.7,67.95 30.8,68.06 30.8,68.18 30.6,68.39 30.37,68.39 30.13,68.63 30.13,68.95 30,69.07 Q13.3
N18863456: length 6.3
  TOP w0.109: U40.B2 185.38,36.27 185.71,36.6 v4(187.21,36.6) 187.35,36.74 C1000.1 188.05,37.24 188.27,37.46 R1000.1 188.27,38.01 188.95,38.69 D1000.1
N19179626: length 1.9
  TOP w0.109: U23.10 38.21,53.03 38.28,53.11 38.28,53.94 38.19,54.03 C297.1
N19268068: length 7.9
  TOP w0.203: v3(57.81,18.86) 57.99,18.67 U9.4
  IN4 w0.762: v3(54.96,14.24) 54.96,17.04 56.78,18.86 v3(57.81,18.86)
N19268072: length 9.8
  TOP w0.203: v4(60.52,21.22) 60.61,21.13 U9.38
  IN4 w0.762: v2(59.23,29.74) 60.52,28.45 v4(60.52,21.22)
N19268120: length 15.4
  TOP w0.203: U9.2 58.86,19.47 57.88,20.46 v3(57.88,20.94)
  IN4 w0.762: v3(47.41,14.43) 49.59,14.43 56.1,20.94 v3(57.88,20.94)
N19268132: length 2.8
  TOP w0.762: 58.46,23.37 58.95,22.88 v4(58.95,22.5) 58.95,21.65 59.33,21.27 59.33,20.89
N19268154: length 1.3
  TOP w0.508: R1006.1 56.52,17.71 56.22,18 C197.2
N19268156: length 1.4
  TOP w0.508: C198.2 61.26,23.13 61.62,22.77 R1007.2
N19268229: length 2.5
  TOP w0.203: U9.5 58.25,18.27 58.19,18.32 57.39,18.32 57.22,18.49 R1006.2
N19268231: length 0.7
  TOP w0.203: U9.37 61.01,21.14 61.04,21.17
N19268506: length 1.2
  BOTTOM w0.114: C1007.1 56.22,12.59 R1003.2
N19268516: length 1.2
  BOTTOM w0.114: C1009.1 56.24,11.59 R1005.2
N19268589: length 0.8
  BOTTOM w0.254: R27309.2 Q1009.3
N19268616: length 1.6
  TOP w0.109: R1009.1 60.97,14.34 61.13,14.5 61.13,15.1 61.41,15.38 U9.15
N19268722: length 2.2
  TOP w0.109: U9.26 65.66,18.27 65.7,18.31 C1011.1
N19268752: length 1.4
  TOP w0.109: v2(64.71,17.5) 64.69,17.47 U9.24
  BOTTOM w0.114: v2(64.71,17.5) 64.56,17.65 R363.1
N19268837: length 3.3
  TOP w0.109: v2(59.84,14.91) 59.81,14.93 U9.11
  BOTTOM w0.114: v2(59.84,14.91) 59.66,14.73 58,14.73 R227.1
N19280052: length 3.1
  TOP w0.079: U17.M6 158.01,23.69 158.08,23.76 158.44,23.76 158.79,23.41
  TOP w0.109: R27292.1 v4(159.15,23.3) 158.9,23.3 158.79,23.41
N19280076: length 6
  TOP w0.254: C112.1 144.88,24.32 147.46,24.32 148.01,23.78 v4(148.13,23.78) 148.21,23.69 U17.A6
N19296116: length 2
  TOP w0.079: U17.H5 v1(154.86,22.72)
  BOTTOM w0.079: v1(154.86,22.72) 155.19,23.04 155.19,24.06 TP114.1
N19296675: length 3.3
  TOP w0.079: 158.79,22.79 158.08,22.79 157.97,22.91 157.53,22.91 157.4,23.04 U17.M5
  TOP w0.109: 158.79,22.79 159.94,22.79 TP86.1
N19296851: length 1.1
  TOP w0.109: Q23.3 153.94,16.83 153.66,17.11 R286.2
N19296894: length 1.2
  TOP w0.079: U17.H4 v1(154.86,22.07)
  BOTTOM w0.114: v1(154.86,22.07) 155.34,21.58 R27291.1
N19413580: length 2.1
  TOP w0.109: U37.6 25.41,60.01 v4(26.15,59.27) R27302.2
N19413585: length 1.4
  TOP w0.109: R27303.2 25.99,60.03 25.51,60.51 U37.7
N19413590: length 1.3
  TOP w0.109: U37.8 25.67,61.01 25.94,60.74 R27304.2
N19413661: length 1.7
  TOP w0.109: R27305.1 20.54,59.93 20.96,59.51 U37.16
N19413668: length 1.9
  TOP w0.109: R27306.1 21.1,60.01 U37.15
N19634590: length 7.9
  BOTTOM w0.114: R91349.2 186.92,51.3 189.27,53.65 J12.14
N19680857: length 9.6
  BOTTOM w0.114: J12.2 192.04,59.65 189.98,61.71 R91325.2
N19699399: length 10.6
  BOTTOM w0.114: J12.3 191.73,59.15 189.22,61.66 R91324.2
N19966883: length 1.3
  BOTTOM w0.114: U4100.42 40.85,25.01 40.85,25.01 TP122.1
N19966886: length 2.6
  BOTTOM w0.114: TP123.1 41.35,26.85 U4100.43
N20128078: length 2.7
  BOTTOM w0.114: R313.1 173.26,31.51 172.92,31.17 172.92,30.98 172.42,30.48 171.93,30.48 171.67,30.23 U42.4
N20313359: length 2
  TOP w0.109: Q1002.2 46.94,67.82 47.14,67.63 R91337.2 47.67,67.22 47.77,67.12 Q1010.3
N20313437: length 1.5
  TOP w0.254: R91338.2 44.72,68.26 45.1,68.64 Q1002.3
N20647936: length 1.1
  TOP w0.089: U1JSL.CE13 105.23,68.32 v1(105.52,68.61)
  BOTTOM w0.089: 105.94,68.54 105.58,68.54 v1(105.52,68.61)
  BOTTOM w0.114: 105.94,68.54 R91342.1
N21257964: length 2.2
  TOP w0.305: R91354.2 16.84,22 U2.6
N21258000: length 2
  TOP w0.305: U2.5 16.69,22.5 16.07,21.88 R91355.2
N21258275: length 1.8
  TOP w0.305: R91356.2 20.63,12.52 20.69,12.58 U4.6
N21258324: length 1.9
  TOP w0.305: U4.5 20.41,13.08 R91357.2
N21276426: length 15.3
  TOP w0.109: R196.1 10.04,17.62 7.23,14.81 7.23,13.37 5.78,11.92 3.52,11.92 3.42,11.83 DS1.5
N21276500: length 14.5
  TOP w0.109: DS1.1 5.74,11.33 7.51,13.09 7.51,14.71 10.14,17.33 15.58,17.33 15.7,17.46 R195.1
N21276510: length 17
  TOP w0.109: DS1.3 4.15,10.71 4.26,10.6 5.55,10.6 7.89,12.94 7.89,14.69 10.28,17.08 16.19,17.08 16.46,17.36 R194.1

## Copper pours and planes (outline as drawn)
1V1_DRAM_LGATE on TOP (solid shape): 172.64,45.55 172.64,44.65 172.38,44.39 171.17,44.39 170.8,44.76 170.8,45.64 170.95,45.79 172.4,45.79
1V1_DRAM_LGATE on TOP (solid shape): 180.96,44.07 180.96,44.02 180.97,43.97 181,43.91 181,43.76 181.06,43.62 181.06,43.6 181.06,43.52 181.05,43.51 180.96,43.37 180.92,43.21 180.97,43.01 181.11,42.86 181.14,42.84 181.14,42.76 181.13,42.76 181.13,41.8 181.09,41.77 180.84,41.77 180.79,41.82 180.79,42.25 179.67,43.37 179.67,43.97 179.79,44.1 180.94,44.1
1V1_DRAM_LGATE on IN2 (solid shape): 172.68,45.49 172.68,44.73 172.43,44.48 171.29,44.48 171.16,44.6 171.16,45.49 171.29,45.62 172.56,45.62
1V1_DRAM_LGATE on IN2 (solid shape): 180.81,43.97 180.81,42.95 180.68,42.83 179.54,42.83 179.29,43.08 179.29,43.84 179.54,44.1 180.68,44.1
1V1_DRAM_SW on TOP (solid shape): 176.46,44.16 178.65,44.16 180.62,42.19 180.62,41.57 180.62,41.45 180.55,41.37 179.72,41.37 179.63,41.46 179.63,41.47 178.27,42.82 177.72,42.82 177.71,42.82 177.17,42.82 176.97,42.62 176.97,42.62 176.69,42.34 176.69,41.71 176.44,41.46 168.91,41.46 168.6,41.78 168.6,43.77 168.99,44.16 176.46,44.16
1V1_DRAM_UGATE on TOP (solid shape): 172.52,39.8 172.52,39.09 172.23,38.8 171.2,38.79 171.06,38.89 171.06,39.7 171.29,39.92 172.4,39.92
1V8_SW on TOP (solid shape): 79.52,29.96 79.52,25.97 79.12,25.57 76.78,25.57 76.51,25.3 75.4,25.3 75.38,25.32 75.38,25.54 75.42,25.58 76.35,25.58 76.35,25.77 75.45,25.77 75.39,25.84 75.39,26.03 75.44,26.08 76.35,26.08 76.35,26.27 75.39,26.27 75.37,26.29 75.37,26.6 74.77,27.2 74.77,29.71 75.38,30.33 79.15,30.33
3V3_IN on TOP (solid shape): 47.77,42.46 47.77,41.84 47.66,41.73 39.33,41.73 39.26,41.81 39.26,42.22 39.29,42.26 41.6,42.26 41.99,42.64 41.99,43.23 42.69,43.93 42.78,44 42.85,44.1 43.14,44.38 45.85,44.38
3V3_SW on TOP (solid shape): 34.89,46.39 34.89,46.13 35.14,45.87 36.28,45.87 37.02,45.14 37.02,42.42 37.23,42.21 38.31,42.21 38.31,42.22 38.96,42.22 39.07,42.11 39.07,41.4 38.97,41.3 37.55,41.3 37.3,41.05 37.3,40.29 37.09,40.08 34.42,40.08 34.21,40.29 34.21,46.41 34.3,46.5 34.78,46.5
5V_IN on TOP (solid shape): 46.52,36.29 46.52,34.09 46.53,34.09 46.53,33.84 45.94,33.26 42.86,33.26 42.22,32.62 40,32.62 39.95,32.67 39.95,33.11 39.99,33.15 42.05,33.15 42.2,33.15 42.64,33.6 42.64,34.55 43.08,34.99 43.96,34.99 44.24,35.26 44.24,36.49 44.48,36.73 46.08,36.73
5V_SW on TOP (solid shape): 36.93,36.29 36.93,35.65 36.93,35.23 37.78,34.39 37.78,33.38 38.03,33.12 39.72,33.12 39.79,33.05 39.79,32.23 39.71,32.16 38.39,32.16 38.06,31.83 38.06,31.52 37.33,30.79 34.91,30.79 34.63,31.07 34.63,35.11 36.01,36.49 36.74,36.49
AGND_HP on TOP (solid shape): 25.29,43.25 25.29,42.24 25.17,42.12 23.52,42.12 23.5,42.14 23.5,42.41 23.77,42.68 24.29,43.2 24.32,43.22 24.45,43.27 24.59,43.22 24.63,43.19 24.83,43.19 24.89,43.24 24.94,43.27 25,43.29 25.05,43.3 25.06,43.31 25.23,43.31
AGND_HP on TOP (solid shape): 25.29,45.42 25.29,44.85 25.26,44.78 25.19,44.75 25.15,44.75 25.06,44.74 24.93,44.78 24.85,44.89 24.81,45 24.03,45 24.03,45 24,45 23.84,44.93 23.77,44.77 23.77,44.74 23.76,44.73 23.76,44.49 23.73,44.42 23.59,44.39 23.37,44.16 23.3,44.19 23.27,44.2 23.2,44.26 23.21,44.36 23.24,44.42 23.26,44.49 23.26,45.02 23.3,45.1 23.4,45.11 23.46,45.09 23.53,45.09 23.89,45.44 23.53,45.8 23.41,45.78 23.31,45.72 23.24,45.7 23.18,45.72 23.14,45.75 23.1,45.77 23.06,45.78 23.06,45.88 22.95,45.99 22.93,46.1 23.02,46.16 24.55,46.16
AGND_HP on TOP (solid shape): 20.04,46.63 20.11,46.71 20.21,46.69 20.67,46.24 20.75,46.18 20.85,46.16 21.43,46.16 21.43,46.12 21.48,46.02 21.59,45.99 21.92,45.99 21.97,46 22.01,46.02 22.03,46.03 22.39,46.03 22.57,45.86 22.6,45.78 22.57,45.71 22.52,45.64 22.5,45.55 22.5,45.19 22.44,45.09 22.33,45.12 22.21,45.23 22.21,45.49 22.15,45.65 21.99,45.72 21.71,45.72 21.54,45.65 21.48,45.49 21.48,45.19 21.48,45.14 21.46,45.06 21.38,45.02 21.31,45.02 20.93,44.63 20.91,44.63 20.78,44.56 20.72,44.43 20.72,44.41 20.72,44.11 20.73,44.09 20.76,44.01 20.82,43.94 20.86,43.86 20.82,43.78 20.77,43.71 20.75,43.63 20.75,43.35 20.78,43.24 20.87,43.16 20.9,43.15 20.9,43.07 20.67,42.84 20.56,42.82 20.49,42.92 20.49,43.67 20.35,43.81 20.32,43.88 20.36,43.96 20.41,44.02 20.44,44.1 20.44,44.15 20.44,45.08 19.73,45.78 19.73,46.03 20.04,46.34
AGND_HP on TOP (solid shape): outline of 211 points within 1.76,31.81 19.88,47.05
AGND_HP on BOTTOM (solid shape): 2.19,36.92 2.18,36.91 2.07,36.72 2.03,36.5 2.21,36.06 2.65,35.88 3.57,35.88 4.01,36.06 4.19,36.5 4.16,36.68 4.09,36.85 4.09,36.94 4.18,36.99 4.94,36.99 5.03,36.94 5.03,36.83 4.95,36.67 4.93,36.5 5.07,36.11 5.43,35.89 5.44,35.89 6.42,34.91 6.45,34.8 6.35,34.73 3.7,34.73 3.69,34.77 3.35,35.37 2.7,35.61 1.76,35.61 1.76,36.69 2.06,36.99 2.19,36.99
AGND_HP on BOTTOM (solid shape): outline of 824 points within 3.38,31.81 25.29,47.05
AGND_HP on SGND (solid shape): outline of 88 points within 1.76,31.81 25.29,47.05
AGND_HP on IN1 (solid shape): 20.67,46.24 20.75,46.18 20.85,46.16 24.55,46.16 25.29,45.42 25.29,41.28 25.28,41.23 25.24,41.18 24.12,42.3 24.12,44.41 23.6,44.93 23.57,45.03 23.64,45.1 23.82,45.23 23.89,45.44 23.79,45.69 23.53,45.8 23.32,45.73 23.19,45.55 23.12,45.48 23.02,45.5 22.9,45.63 20.36,45.63 19.93,46.06 19.93,46.69 19.74,46.88 19.72,46.99 19.82,47.05 19.85,47.05
AGND_HP on IN1 (solid shape): outline of 657 points within 1.76,31.81 24.94,46.44
AGND_HP on IN2 (solid shape): outline of 1141 points within 1.76,31.81 25.29,47.05
AGND_HP on IN3 (solid shape): outline of 1140 points within 1.76,31.81 25.29,47.05
AGND_HP on IN4 (solid shape): 15.36,45.43 15.47,45.45 15.54,45.36 15.54,42.25 15.03,41.74 15.03,40.81 15.4,40.43 15.42,40.32 15.33,40.26 15.32,40.26 15.09,40.16 14.99,39.93 15.06,39.73 15.23,39.61 15.3,39.54 15.27,39.44 15.26,39.43 15.26,37.91 15.35,37.82 15.37,37.72 15.29,37.65 15.27,37.65 15.19,37.67 15.15,37.75 15.15,39.24 14.77,39.62 14.77,43.16 15.15,43.54 15.15,45.21
AGND_HP on IN4 (solid shape): outline of 112 points within 13.8,31.81 20.01,36.71
AGND_HP on IN4 (solid shape): 4.97,36.99 5.06,36.94 5.06,36.83 4.98,36.67 4.95,36.5 5.13,36.08 5.55,35.9 6.47,35.9 6.89,36.08 7.07,36.5 7.04,36.68 6.96,36.84 6.96,36.94 7.05,36.99 7.72,36.99 7.81,36.94 7.81,36.83 7.73,36.67 7.7,36.5 7.88,36.08 8.3,35.9 8.99,35.9 9.36,35.54 9.38,35.43 9.28,35.37 5.13,35.37 4.15,36.35 4.16,36.43 4.17,36.5 4.14,36.68 4.06,36.84 4.06,36.94 4.15,36.99
AGND_HP on IN4 (solid shape): 16.25,44.8 16.31,44.9 16.42,44.88 16.55,44.75 16.55,44.49 17.4,43.65 21.37,43.65 21.86,44.14 23.79,42.21 23.79,40.68 24.61,39.86 24.64,39.75 24.54,39.69 23.89,39.69 23.77,39.65 23.67,39.56 23.57,39.56 23.4,39.73 23.36,39.75 23.31,39.76 22.27,39.76 22.24,39.79 22.24,40.7 22.23,40.75 22.21,40.79 22.1,40.89 22.06,40.92 22.01,40.93 18.25,40.93 18.21,40.92 18.17,40.89 18.06,40.79 18.04,40.75 18.03,40.7 18.03,37.45 17.9,37.32 17.04,37.32 16.99,37.31 16.95,37.29 16.46,36.8 16.44,36.77 16.43,36.72 16.42,36.67 16.33,36.67 16.33,37.79 16.35,37.86 16.64,38 16.73,38.22 16.69,38.39 16.57,38.51 16.52,38.59 16.55,38.67 16.64,38.79 16.67,38.92 16.57,39.16 16.34,39.25 16.24,39.32 16.27,39.43 16.33,39.5 16.33,40.51 16.17,40.67 16.15,40.76 16.21,40.83 16.35,40.95 16.4,41.13 16.3,41.37 16.07,41.46 15.94,41.44 15.83,41.36 15.81,41.34 15.74,41.34 15.74,41.44 16.25,41.95
AGND_HP on IN4 (solid shape): outline of 147 points within 3.35,35.57 25.29,47.05
AGND_HP on IN5 (solid shape): outline of 1118 points within 1.76,31.81 25.29,47.05
GND on TOP (solid shape): 21.8,24.32 21.8,21.18 21.7,21.08 18.46,21.08 18.37,21.17 18.37,24.22 18.56,24.41 21.71,24.41
GND on TOP (solid shape): 24.28,61.09 24.28,59.47 24.17,59.37 22.55,59.37 22.46,59.46 22.46,61.07 22.56,61.17 24.19,61.17
GND on TOP (solid shape): 25.95,14.96 25.95,11.71 25.86,11.62 22.73,11.62 22.62,11.72 22.62,14.96 22.71,15.05 25.86,15.05
GND on TOP (solid shape): 40.18,69.94 40.18,68.22 40.09,68.13 38.36,68.13 38.27,68.22 38.27,69.94 38.37,70.04 40.07,70.04
GND on TOP (solid shape): 51.41,59.28 51.41,57.83 51.33,57.75 49.71,57.75 49.61,57.85 49.61,59.37 49.7,59.46 51.24,59.46
GND on TOP (solid shape): 63.52,19.84 63.52,16.32 63.42,16.22 59.81,16.22 59.71,16.32 59.71,19.84 59.81,19.94 63.42,19.94
GND on TOP (solid shape): 75.14,26.6 75.14,24.23 75.04,24.13 73.41,24.13 73.32,24.22 73.32,26.59 73.42,26.69 75.05,26.69
GND on TOP (solid shape): 158.08,73.38 158.08,71.33 158.04,71.29 153.66,71.29 153.15,71.79 153.15,73.2 153.46,73.5 157.96,73.5
GND on TOP (solid shape): 172.43,29.24 172.43,26.95 172.3,26.82 170.02,26.82 169.89,26.95 169.89,29.24 170.02,29.36 172.3,29.36
GND on TOP (solid shape): 181.06,54.89 181.06,52.35 180.94,52.22 178.4,52.22 178.27,52.35 178.27,54.76 178.52,55.02 180.94,55.02
GND on TOP (solid shape): 17.04,60.96 17.04,59.05 16.91,58.93 14.3,58.93 13.09,60.14 13.09,61 13.26,61.18 16.82,61.18
GND on TOP (solid shape): 26.9,19.19 26.9,17.41 26.7,17.21 25.92,17.21 25.78,17.35 25.78,19.16 25.9,19.29 26.8,19.29
GND on TOP (solid shape): 77.53,16.39 77.53,14.48 77.43,14.38 75.54,14.38 75.37,14.55 75.37,16.39 75.46,16.48 77.44,16.48
GND on TOP (solid shape): 24.44,28.44 24.44,25.76 24.36,25.69 23.89,25.69 23.79,25.79 23.79,26.22 23.24,26.77 23.24,28.48 23.35,28.59 24.3,28.59
GND on TOP (solid shape): 28.59,45.84 28.59,38.51 28.55,38.47 27.17,38.47 27.03,38.61 27.03,45.16 27.76,45.89 28.54,45.89
GND on TOP (solid shape): 29.48,35.83 29.48,28.3 29.27,28.1 27.32,28.1 27.17,28.24 27.17,35.61 27.52,35.95 29.35,35.95
GND on TOP (solid shape): 77.27,37.29 77.27,35.94 77.16,35.83 75.93,35.83 75.59,36.17 75.59,37.28 75.83,37.52 77.04,37.52
GND on TOP (solid shape): 152.01,30.94 152.01,29.94 151.76,29.68 150.47,29.68 149.75,30.4 149.75,31.18 149.85,31.28 151.68,31.28
GND on TOP (solid shape): 154.29,83.08 154.29,79.91 154,79.61 150.04,79.61 149.84,79.81 149.84,82.98 150.04,83.18 154.2,83.18
GND on TOP (solid shape): 164.48,76.41 164.48,75.75 164.38,75.65 161.35,75.65 161.24,75.75 161.24,76 161.6,76.35 161.62,76.35 161.78,76.52 164.38,76.52
GND on TOP (solid shape): 182.72,41.43 182.72,39.9 182.59,39.78 181.06,39.78 180.97,39.87 180.97,41.41 181.09,41.52 182.63,41.52
GND on TOP (solid shape): 57.56,24.37 57.56,22.78 57.46,22.68 56.73,22.68 56.3,22.25 54.03,22.25 53.87,22.42 53.87,24.32 54.07,24.52 57.41,24.52
GND on TOP (solid shape): 21.91,40.48 21.91,37.17 21.79,37.05 18.48,37.05 18.36,37.17 18.36,38.77 18.38,38.79 18.38,39.67 18.36,39.69 18.36,40.48 18.48,40.6 21.79,40.6
GND on TOP (solid shape): 48.91,18.35 48.91,15.3 48.79,15.17 46.77,15.17 46.42,15.53 46.42,18.3 46.6,18.48 48.79,18.48
GND on TOP (solid shape): 80.21,61.57 80.21,60.56 79.19,59.54 78.58,59.54 78.1,60.02 76.98,60.02 76.64,60.36 76.64,61.51 76.75,61.62 80.16,61.62
GND on TOP (solid shape): 144.98,84.37 144.98,81.9 144.68,81.6 139.13,81.6 138.84,81.3 135.97,81.3 135.37,81.9 130.91,81.9 130.72,82.09 130.72,83.18 132.4,84.87 144.49,84.87
GND on TOP (solid shape): 161.49,51.78 161.49,50.26 161.3,50.07 161.08,50.07 160.8,50.35 156.65,50.35 156.65,51.6 156.93,51.89 161.38,51.89
GND on TOP (solid shape): 36.55,39.89 37.15,39.89 37.36,39.69 37.36,38.67 37.1,38.42 35.91,38.42 35.63,38.14 34.24,38.14 34.13,38.26 34.13,39.78 34.25,39.9 36.54,39.9
GND on TOP (solid shape): 75.57,53.04 75.57,50.87 75.13,50.44 72.35,50.44 72.18,50.61 72.18,52.68 72.69,53.2 75.41,53.2
GND on TOP (solid shape): 179,65.13 179,63.98 178.45,63.43 176.05,63.43 175.93,63.31 175.83,63.31 175.83,63.31 175.68,63.31 175.39,63.02 174.36,63.02 173.44,63.94 173.44,65.18 173.57,65.3 178.82,65.3
GND on TOP (solid shape): 41.76,22.46 41.76,16.12 42.46,15.42 42.46,9.98 42.35,9.88 33.34,9.88 33.24,9.98 33.24,12.95 33.31,13 33.37,13.07 34.93,14.64 34.93,21.87 35.62,22.56 41.66,22.56
GND on TOP (solid shape): 64.15,61.28 64.15,58.86 63.9,58.61 58.51,58.61 58.38,58.74 58.38,60.23 57.89,60.72 57.89,61.27 58.15,61.53 63.9,61.53
GND on TOP (solid shape): 16.61,30.34 16.61,29.63 17.16,29.08 17.56,29.08 17.75,29.28 17.75,29.61 17.89,29.74 19.64,29.74 19.76,29.63 19.76,28.87 19.68,28.79 16.66,28.79 15.93,29.51 15.93,30.19 16.19,30.45 16.5,30.45
GND on TOP (solid shape): 47.77,41.38 47.77,37.86 47.66,37.75 43.64,37.75 43.01,38.38 39.81,38.38 38.88,39.3 38.88,40.35 39.25,40.73 39.25,41.5 39.29,41.54 47.61,41.54
GND on TOP (solid shape): 54.37,53.15 54.37,51.88 54.21,51.72 45.13,51.72 45.03,51.82 45.03,53.16 45.23,53.37 50.1,53.37 50.11,53.38 54.14,53.38
GND on TOP (solid shape): 36.26,51.91 40.53,51.91 40.6,51.84 40.6,51.21 39.25,51.21 39,50.97 36.16,50.97 36.02,50.83 36.02,50.46 35.84,50.28 35.44,50.28 35.35,50.37 35.35,51.94 35.42,52.02 36.16,52.02
GND on TOP (solid shape): 47.4,33.91 47.4,33.35 47.87,32.88 47.87,29.56 47.5,29.19 40.81,29.19 40.81,29.19 40.24,29.19 39.94,29.49 39.94,32.39 39.99,32.44 42.34,32.44 42.92,33.01 45.95,33.01 46.96,34.02 47.29,34.02
GND on TOP (solid shape): 71.75,37.68 71.75,37.25 72.07,36.92 73.17,36.92 73.23,36.86 73.42,36.86 73.5,36.79 73.5,30.89 73.32,30.71 71.8,30.71 71.59,30.92 71.59,30.93 71.17,31.35 71.17,34.12 70.87,34.43 70.69,34.43 70.49,34.62 70.49,37.97 70.57,38.05 71.39,38.05
GND on TOP (solid shape): 98.55,41.25 98.55,40.51 98.43,40.39 98.43,39.54 97.86,38.97 97.76,38.97 97.69,39.04 97.69,39.2 97.78,39.28 97.85,39.38 97.85,39.39 97.89,39.42 97.89,40.32 97.79,40.42 97.79,41.31 97.83,41.35 98.45,41.35
GND on TOP (solid shape): 60.03,43.3 60.03,41.48 60,41.39 59.99,41.3 60,41.22 60.03,41.13 60.03,41.05 59.85,40.86 52.31,40.86 52.09,41.08 52.09,43.5 52.22,43.62 59.71,43.62
GND on TOP (solid shape): 103.52,80.88 103.52,75.56 102.71,74.75 102.71,74.4 102.69,74.39 102.69,73.83 102.42,73.55 102.2,73.55 102.07,73.69 102.07,74.86 101.58,75.35 96.51,75.35 96.24,75.63 95.64,75.63 95.37,75.35 93.04,75.35 92.98,75.41 92.98,75.77 93.11,75.89 101.05,75.89 101.44,76.27 101.44,79.91 101.27,80.07 95.72,80.07 95.36,80.44 95.36,81.5 95.46,81.6 102.81,81.6
GND on TOP (solid shape): 31.7,66.72 31.7,65.96 31.73,65.92 32.4,65.92 32.56,65.77 32.56,61.35 32.49,61.29 31.76,61.29 31.7,61.22 31.7,60.42 31.66,60.38 31.51,60.38 31.49,60.4 31.49,61.14 31.37,61.27 31.07,61.27 31.02,61.32 31.02,65.83 31.12,65.92 31.43,65.92 31.49,65.98 31.49,66.74 31.51,66.76 31.66,66.76
GND on TOP (solid shape): 83.27,77.74 83.27,77.4 79.33,73.47 78.91,73.47 78.32,74.07 78.32,74.73 80.18,76.59 80.3,76.5 80.44,76.46 80.7,76.57 80.8,76.82 80.77,76.97 80.68,77.09 81.48,77.89 83.11,77.89
GND on TOP (solid shape): 172.17,52.1 172.17,50.57 172.66,50.08 173.95,50.08 174.94,49.1 176.62,49.1 178.1,47.61 178.1,44.75 177.89,44.54 173.25,44.54 173.06,44.73 173.06,46 172.89,46.18 164.58,46.18 161.8,48.96 161.8,50.24 161.92,50.36 162.55,50.36 163.18,49.73 166.37,49.73 166.65,49.45 166.65,48.39 167.31,47.73 168.76,47.73 168.84,47.82 168.84,50 168.61,50.23 168.61,51.97 168.87,52.22 172.05,52.22
GND on TOP (solid shape): 56.38,39.39 56.38,38.78 57.19,37.97 57.87,37.97 57.92,37.97 58.29,37.61 58.3,37.59 58.32,37.58 58.41,37.49 60.16,37.49 60.25,37.4 60.25,37.17 60.29,37.13 60.29,35.82 60.25,35.78 60.25,35.55 60.16,35.46 58.38,35.46 58.26,35.59 58.26,36.98 58.14,37.1 58.01,37.1 57.23,37.1 56.93,37.4 55.59,37.4 55.01,37.98 51.9,37.98 51.77,38.12 51.77,39.2 51.97,39.4 52.36,39.4 52.56,39.59 52.56,40.24 52.76,40.43 55.34,40.43
GND on TOP (solid shape): 142.41,73.56 145.11,73.56 146.81,71.86 152.73,71.86 153.63,70.97 157.84,70.97 158.27,70.54 158.27,69.23 158.44,69.06 159.11,69.06 159.15,69.02 159.15,68.11 159.02,67.98 143.88,67.98 143.12,68.74 143.07,68.74 142.99,68.81 142.89,68.84 142.59,68.84 142.48,68.81 142.4,68.74 136.5,68.74 136.45,68.78 136.45,69.01 136.69,69.26 137.45,69.26 137.46,69.27 137.56,69.27 137.57,69.25 137.77,69.25 138.04,69.53 138.65,69.53 139.69,70.57 139.69,71.13 139.97,71.41 140.94,71.41 141.42,71.89 141.42,73.88 141.54,74 141.98,74
GND on TOP (solid shape): 155.59,17.72 155.59,17.4 155.59,17.33 155.97,16.95 156.17,16.95 156.19,16.93 156.23,16.89 156.29,16.88 156.56,16.88 156.61,16.83 156.61,15.56 156.48,15.43 155.72,15.43 155.59,15.56 155.59,16.09 155.63,16.18 155.64,16.27 155.55,16.5 155.31,16.6 155.28,16.6 155.24,16.59 155.15,16.61 155.11,16.69 155.11,17.02 155.09,17.09 155.04,17.13 155.03,17.14 154.7,17.46 154.7,17.71 154.83,17.84 155.47,17.84
GND on TOP (solid shape): 48.15,61.28 48.15,60.51 47.52,59.88 47.52,59.37 47.26,59.12 46.14,59.12 45.93,59.32 45.95,59.35 45.99,59.44 46,59.53 45.9,59.79 45.65,59.89 45.57,59.88 45.5,59.86 45.4,59.87 45.36,59.95 45.36,60.64 45.61,60.64 45.61,60.54 45.8,60.35 45.81,60.34 45.94,60.21 46.12,60.16 46.24,60.18 46.34,60.23 46.53,60.23 46.64,60.18 46.75,60.16 46.86,60.17 46.96,60.22 46.98,60.23 47.52,60.77 47.52,61.28 47.64,61.4 48.02,61.4
GND on TOP (solid shape): 58.27,33.82 58.27,33.81 58.64,33.43 58.64,33.2 59.18,32.66 59.15,32.56 59.14,32.48 59.24,32.23 59.49,32.13 59.62,32.15 59.73,32.21 59.79,32.24 59.86,32.21 59.94,32.16 60.02,32.13 60.04,32.13 60.32,31.85 60.32,31.84 60.81,31.35 60.81,31.35 60.83,31.34 65.56,31.34 65.81,31.59 70.15,31.59 72.29,29.45 72.29,29.3 72.48,29.1 72.48,28.73 72.35,28.6 71.72,28.6 71.46,28.35 71.46,28.19 71.34,28.06 68.07,28.06 67.93,28.2 67.93,28.85 66.77,30.01 60.08,30.01 59.36,30.74 58.78,30.74 58.49,31.02 58.49,31.75 57.85,32.38 53.01,32.38 52.69,32.7 52.69,35.25 52.83,35.38 56.71,35.38
GND on TOP (solid shape): 170.65,39.65 170.65,38.38 170.9,38.13 172.38,38.13 172.6,37.91 172.6,37.88 172.83,37.65 172.83,32.58 172.66,32.41 171.8,32.41 171.79,32.41 165.43,32.41 165.41,32.43 165.38,32.48 165.33,32.51 165.28,32.54 165.23,32.56 165.17,32.57 165.12,32.58 165.06,32.57 165.01,32.56 164.95,32.54 164.91,32.51 164.86,32.48 164.82,32.43 164.81,32.41 164.23,32.41 163.46,31.64 163.42,31.63 163.38,31.61 163.34,31.58 163.3,31.55 163.27,31.51 163.25,31.47 163.24,31.45 163.24,30.72 162.83,30.31 162.83,29.4 162.58,29.14 161.18,29.14 160.93,29.4 160.93,30.81 162.54,30.81 162.54,32 162.35,32 162.35,30.81 162.04,30.81 162.04,32 161.85,32 161.85,30.81 161.54,30.81 161.54,32 161.35,32 161.35,30.81 160.93,30.81 160.93,31.98 161.32,32.37 161.32,34.27 161.49,34.44 168.94,34.44 169.25,34.76 169.25,36.48 168.87,36.86 168.87,39.65 169,39.78 170.52,39.78
GND on TOP (solid shape): 11.37,53.92 11.37,53.19 11.3,53 11.27,52.8 11.3,52.6 11.37,52.41 11.37,51.6 11.83,51.14 12.91,51.14 13.31,50.74 13.31,50.03 11.32,48.04 9.81,48.04 9.68,48.03 9.55,48.03 9.45,48.03 9.35,48.03 8.64,48.15 8.02,48.53 4.67,48.53 4.67,48.48 4.73,48.33 4.77,48.17 4.8,48.02 4.82,47.87 4.82,47.79 4.82,47.63 4.82,47.56 3.91,47.56 3.84,47.59 3.81,47.67 3.81,47.7 3.8,47.78 3.8,47.87 3.68,48.22 3.46,48.51 3.46,49.24 3.76,49.54 8.48,49.54 8.85,49.18 9.35,49.04 10.06,49.34 10.36,50.05 10.36,53.95 10.49,54.08 11.22,54.08
GND on TOP (solid shape): 131.84,79.24 132.15,78.93 135.31,78.93 135.69,78.56 135.69,76.82 135.93,76.58 139.85,76.58 139.96,76.47 139.96,74.36 139.86,74.26 139.43,74.26 138.89,73.72 138.17,73.72 138.17,73.77 137.79,74.13 137.41,73.77 137.4,73.72 135.89,73.72 133.61,76 133.61,76.27 133.73,76.39 134.01,76.39 134.13,76.51 134.13,76.68 134.14,76.73 134.14,76.77 134.14,76.81 134.13,76.86 134.13,77.31 134.14,77.36 134.14,77.4 134.05,77.63 133.83,77.72 133.72,77.7 133.62,77.65 132.37,77.65 131.8,78.23 131.72,78.26 131.7,78.33 131.79,78.45 131.82,78.6 131.72,78.85 131.46,78.96 131.33,78.93 131.22,78.86 131.21,78.85 131.18,78.84 131.11,78.88 131.08,78.9 130.98,78.94 130.81,78.95 130.74,78.93 130.71,78.97 130.7,79.01 130.7,79.64 131.44,79.64
GND on TOP (solid shape): outline of 189 points within 164.76,66.07 179.13,75.89
GND on TOP (solid shape): outline of 144 points within 136.38,52.48 148.9,63.58
GND on TOP (solid shape): outline of 1080 points within 0.51,0.51 197.69,88.89
GND on BOTTOM (solid shape): 25.95,14.77 25.95,11.71 25.86,11.62 22.81,11.62 22.62,11.81 22.62,14.77 22.81,14.96 25.76,14.96
GND on BOTTOM (solid shape): 177.91,27.75 177.91,24.6 177.82,24.51 173.82,24.51 173.63,24.7 173.63,27.85 173.72,27.94 177.72,27.94
GND on BOTTOM (solid shape): 32.84,66.3 32.84,62.16 32.63,61.95 30.89,61.95 30.68,62.16 30.68,66.66 30.75,66.74 32.4,66.74
GND on BOTTOM (solid shape): 115.72,81.21 115.72,79.69 115.59,79.56 112.41,79.56 112.16,79.82 112.16,81.21 112.41,81.47 115.46,81.47
GND on BOTTOM (solid shape): 21.94,40.58 21.94,39.57 21.95,39.56 21.95,37.31 21.65,37.02 18.38,37.02 18.29,37.11 18.29,40.58 18.38,40.67 21.85,40.67
GND on BOTTOM (solid shape): 95.02,51.92 95.02,50.27 94.88,50.13 93.97,50.13 93.97,50.13 93.11,50.13 92.46,49.47 91.37,49.47 91.09,49.75 91.09,51.83 91.35,52.1 94.84,52.1
GND on BOTTOM (solid shape): 85.74,16.99 85.74,16.44 85.53,16.23 85.53,15.16 85.39,15.02 83.62,15.02 83.39,15.26 83.39,15.71 84.73,17.06 85.67,17.06
GND on BOTTOM (solid shape): 96.29,75.93 100.82,75.93 101.15,75.6 101.26,75.49 101.26,74.56 101.11,74.41 100.48,74.41 100.43,74.45 100.43,74.46 100.19,74.7 92.49,74.7 91.22,75.97 91.22,76.49 91.27,76.54 95.69,76.54
GND on BOTTOM (solid shape): 42.26,22.95 42.26,10.44 42.54,10.16 43.69,10.16 44.45,10.92 45.28,10.92 45.49,10.71 45.49,8.04 45.13,7.68 33.44,7.68 33.23,7.89 33.23,9.38 33.31,9.46 35.2,9.46 35.9,10.17 35.9,22.99 35.96,23.05 42.16,23.05
GND on BOTTOM (solid shape): 165.88,72.2 166.39,72.2 167.02,71.56 167.97,71.56 168.09,71.69 168.09,71.83 168.24,71.97 168.43,71.97 168.43,71.22 168.67,71.22 168.67,71.97 168.89,71.97 168.89,71.82 168.93,71.77 168.93,71.22 168.98,71.22 168.98,70.17 167.38,70.17 166.13,71.42 166.07,71.42 165.95,71.54 163.67,71.54 163.12,72.08 163.12,72.5 163.44,72.81 165.27,72.81
GND on BOTTOM (solid shape): 63.65,19.49 63.65,17.97 63.57,17.9 63.44,17.9 62.63,17.9 62.58,17.89 62.54,17.86 62.52,17.84 62.28,17.84 62.23,17.89 62.17,17.9 61.21,17.9 61.15,17.89 61.1,17.84 59.84,17.84 59.71,17.97 59.71,19.49 59.94,19.72 63.42,19.72
GND on BOTTOM (solid shape): 178.88,55.28 178.88,53.58 178.71,53.4 177.69,53.4 176.64,54.46 176.61,54.52 176.62,54.59 176.66,54.58 176.7,54.58 177.05,54.94 176.7,55.29 176.52,55.25 176.39,55.12 176.35,55.1 176.3,55.12 176.29,55.14 176.29,55.69 176.42,55.81 178.35,55.81
GND on BOTTOM (solid shape): 160.01,78.37 160.24,78.29 160.47,78.37 161.99,78.37 162.07,78.34 162.1,78.26 162.09,78.24 162.2,77.99 162.45,77.89 162.65,77.95 162.78,78.1 162.85,78.16 162.94,78.13 164.47,76.61 164.47,75.64 164.3,75.47 161.44,75.47 161.05,75.86 161.05,75.88 159.91,77.02 159.02,77.02 158.95,77.1 158.95,78.32 159,78.37
GND on BOTTOM (solid shape): 11.37,53.91 11.37,53.19 11.3,53 11.27,52.8 11.3,52.6 11.37,52.41 11.37,51.59 11.82,51.14 12.91,51.14 13.31,50.74 13.31,50.01 11.33,48.03 9.55,48.03 9.45,48.03 9.35,48.03 8.64,48.15 8.02,48.53 4.67,48.53 4.67,48.48 4.73,48.33 4.77,48.17 4.8,48.02 4.82,47.87 4.82,47.78 4.82,47.7 4.82,47.63 4.82,47.56 3.91,47.56 3.84,47.59 3.81,47.66 3.81,47.7 3.8,47.78 3.8,47.87 3.68,48.22 3.46,48.51 3.46,49.24 3.76,49.54 8.48,49.54 8.85,49.18 9.35,49.04 10.06,49.34 10.36,50.05 10.36,53.92 10.47,54.03 11.25,54.03
GND on BOTTOM (solid shape): outline of 891 points within 0.51,0.51 197.69,88.89
GND on BOTTOM (solid shape): outline of 24894 points within 90.64,24.01 181.87,66.32
GND on SGND (solid shape): outline of 1125 points within 0.51,0.51 197.69,88.89
GND on IN1 (solid shape): 115.84,81.34 115.84,79.69 115.46,79.31 112.92,79.31 112.13,80.1 112.13,80.99 112.72,81.57 115.61,81.57
GND on IN1 (solid shape): 95.02,51.92 95.02,50.27 94.88,50.13 93.11,50.13 92.46,49.47 91.37,49.47 91.09,49.75 91.09,51.83 91.29,52.04 94.9,52.04
GND on IN1 (solid shape): 11.37,53.88 11.37,53.14 11.32,52.97 11.3,52.8 11.32,52.63 11.37,52.46 11.37,51.61 11.84,51.15 12.9,51.15 13.31,50.74 13.31,50.03 11.31,48.03 9.71,48.03 9.63,48.03 9.55,48.03 9.45,48.03 9.35,48.03 8.64,48.15 8.02,48.53 4.67,48.53 4.67,48.48 4.73,48.33 4.77,48.17 4.8,48.02 4.82,47.87 4.82,47.78 4.82,47.7 4.82,47.63 4.82,47.56 3.8,47.56 3.81,47.63 3.81,47.7 3.8,47.78 3.8,47.87 3.68,48.22 3.46,48.51 3.46,49.24 3.76,49.54 8.48,49.54 8.85,49.18 9.35,49.04 10.06,49.34 10.36,50.05 10.36,53.92 10.48,54.03 11.22,54.03
GND on IN1 (solid shape): outline of 1790 points within 0.51,0.51 197.69,88.89
GND on IN2 (solid shape): 115.72,81.21 115.72,79.69 115.59,79.56 112.41,79.56 112.16,79.82 112.16,81.21 112.41,81.47 115.46,81.47
GND on IN2 (solid shape): 95.02,51.92 95.02,50.27 94.94,50.19 94.05,50.19 93.99,50.13 93.11,50.13 92.63,49.64 91.19,49.64 91.09,49.75 91.09,51.83 91.35,52.1 94.84,52.1
GND on IN2 (solid shape): 11.37,53.99 11.37,53.14 11.32,52.97 11.3,52.8 11.32,52.63 11.37,52.46 11.37,51.6 11.83,51.14 12.91,51.14 13.31,50.74 13.31,50.03 11.3,48.03 9.55,48.03 9.45,48.03 9.35,48.03 8.64,48.15 8.02,48.53 4.67,48.53 4.67,48.48 4.73,48.33 4.77,48.17 4.8,48.02 4.82,47.87 4.82,47.78 4.82,47.7 4.82,47.63 4.82,47.56 3.8,47.56 3.81,47.63 3.81,47.7 3.8,47.78 3.8,47.87 3.68,48.22 3.46,48.51 3.46,49.24 3.76,49.54 8.48,49.54 8.85,49.18 9.35,49.04 10.06,49.34 10.36,50.05 10.36,53.96 10.44,54.05 11.32,54.05
GND on IN2 (solid shape): outline of 195 points within 0.51,0.51 197.69,88.89
GND on IN2 (solid shape): outline of 23358 points within 90.7,25.84 163.56,64.99
GND on IN3 (solid shape): 112.45,33.52 112.56,33.54 112.62,33.45 112.62,33.25 110.27,30.89 110.07,30.89 109.97,30.95 110,31.06
