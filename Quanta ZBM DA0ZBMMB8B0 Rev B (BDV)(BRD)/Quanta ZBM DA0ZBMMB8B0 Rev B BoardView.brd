# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1P05EXT_FB: length 5.8
  TOP w0.254: U33.5 60.02,38.34 60.54,38.86 v2(60.54,39.1)
  BOTTOM w0.203: v2(60.54,39.1) 60.38,38.95 60.38,36.83 60.71,36.5 R294.1 R293.2 61.71,35.96 C28003.2
VCCIN_AUX_SENSE_N: length 84.4
  TOP w0.089: v2(118,70.8) 117.58,70.5 U1JSL.AU8
  TOP w0.109: v2(49.67,56.07) 50.11,56.52 U21.7
  IN1 w0.097: v2(49.67,56.07) 49.88,56.29 49.88,57.26 49.17,57.97 49.17,59.37 49.75,59.95 51.65,59.95 53.68,61.98 54.65,61.98 55.91,63.24 65.26,63.24 65.75,62.75 69.66,62.75 70,62.42 72.69,62.42 75.53,65.27 76.64,65.27 78.8,67.43 85.36,67.43 86.87,68.94 89.42,68.94 89.92,68.43 91.17,68.43 91.7,67.91 94.96,67.91 95.63,67.23 99.22,67.23 100.89,65.56 105.62,65.56 106.67,66.61 110.76,66.61 111.27,67.12 111.27,67.88 113.05,69.66 117.21,69.66 117.49,69.94 117.49,70.2 118,70.71 v2(118,70.8)
  BOTTOM w0.109: v2(49.67,56.07) 49.85,55.89 49.85,55.39 49.77,55.32 R242.1
VCCIN_AUX_SENSE_P: length 85.9
  TOP w0.089: v2(118,70.17) 118.14,70.03 118.14,69.81 118.01,69.68 117.71,69.68 U1JSL.AU9
  TOP w0.109: R439.2 49.77,55.49 49.85,55.41 R440.2 50.26,56.04 v2(50.27,56.05) 50.27,56.16 50.51,56.39 U21.8
  IN1 w0.097: v2(50.27,56.05) 50.08,56.25 50.08,57.35 49.37,58.06 49.37,59.29 49.83,59.75 51.73,59.75 53.76,61.78 54.73,61.78 55.99,63.04 65.18,63.04 65.67,62.55 69.58,62.55 69.91,62.22 72.77,62.22 75.62,65.07 76.72,65.07 78.88,67.23 85.44,67.23 86.95,68.74 89.34,68.74 89.84,68.24 91.09,68.24 91.62,67.71 94.88,67.71 95.55,67.04 99.13,67.04 100.81,65.36 105.7,65.36 106.75,66.41 110.84,66.41 111.47,67.04 111.47,67.8 113.13,69.46 117.29,69.46 117.69,69.86 117.69,70.11 117.81,70.23 117.94,70.23 v2(118,70.17)
  BOTTOM w0.109: R241.2 50.14,55.32 50.06,55.39 50.06,55.84 v2(50.27,56.05)
VCCIN_AUX_VID0: length 221.8
  TOP w0.079: v1(152.91,25.97) U17.F9
  TOP w0.109: R393.2 97.12,54 v2(97.88,53.24) 98.77,54.13 100.29,54.13 100.55,54.38 101.03,54.38 U1JSL.CP44 ; U21.18 50.51,61.88 51.65,63.03 51.65,64.04 52.01,64.4 52.01,64.97 53.77,66.74 56.28,66.74 56.4,66.86 Q26.2 56.4,67.92 v2(56.22,68.1)
  IN2 w0.079: 152.49,26.99 152.58,26.89 152.58,26.27 152.88,25.97 v1(152.91,25.97)
  IN2 w0.097: 152.49,26.99 149.26,26.99 147.74,28.51 146.57,28.51 145.64,29.44 144.21,29.44 140.32,25.55 138.39,25.55 136.17,23.33 134.26,23.33 133,22.06 131.51,22.06 131.1,21.65 126.57,21.65 125.96,22.26 120.42,22.26 119.67,21.51 119.34,21.51 118.4,22.46 107.63,22.46 106.48,23.61 98.46,23.61 98.03,24.04 91.02,24.04 84.31,30.76 84.31,45.25 87.7,48.64 89.85,48.64 90.02,48.81 93.41,48.81 94.2,48.02 96.24,48.02 97.55,49.33 97.55,52.91 v2(97.88,53.24)
  IN4 w0.089: v2(40.76,57.85) 41.39,58.48 47.52,58.48 51.86,62.83 51.86,63.74 v2(56.22,68.1)
  BOTTOM w0.117: v2(40.76,57.85) 40.76,57.82 41.24,57.34 43.29,57.34 44.14,56.49 44.14,50.68 49.74,45.08 61.49,45.08 63.3,43.27 68.71,43.27 69.82,44.38 71.54,44.38 73.93,46.77 79.83,46.77 82.87,49.82 87.29,49.82 90.56,53.09 96.72,53.09 97.21,52.61 97.65,52.61 97.88,52.84 v2(97.88,53.24)
VCCIN_AUX_VID1: length 217.4
  TOP w0.079: 148.81,26.02 149.71,26.02 149.75,25.97 150.31,25.97 U17.B9
  TOP w0.109: R392.2 v2(97.24,53.24) 97.63,52.86 98.13,52.86 99.15,53.87 100.29,53.87 100.59,53.58 U1JSL.CP45 ; v2(58.68,68.11) Q27.2 58.68,66.98 58.18,66.48 53.9,66.48 52.28,64.86 52.28,64.27 51.96,63.94 51.96,62.98 50.91,61.92 U21.17 ; 148.81,26.02 144.89,26.02 144.36,26.54 142.94,26.54 142.73,26.76 v2(142.7,26.76)
  IN2 w0.097: v2(97.24,53.24) 97.17,53.17 97.17,49.24 96.35,48.41 94.16,48.41 93.53,49.04 89.97,49.04 89.77,48.84 87.46,48.84 84.11,45.49 84.11,30.65 90.91,23.85 97.93,23.85 98.38,23.39 106.41,23.39 107.54,22.26 118.29,22.26 119.24,21.32 119.77,21.32 120.52,22.06 125.86,22.06 126.48,21.44 131.19,21.44 131.61,21.87 133.1,21.87 134.33,23.09 136.25,23.09 138.5,25.33 140.53,25.33 141.95,26.76 v2(142.7,26.76)
  IN4 w0.089: v2(41.34,57.85) 47.52,57.85 51.83,62.16 52.74,62.16 v2(58.68,68.11)
  BOTTOM w0.117: v2(41.34,57.85) 43.16,57.85 44.47,56.54 44.47,50.99 v4(47.1,48.36) 50.13,45.32 61.6,45.32 63.4,43.52 68.61,43.52 69.73,44.64 71.45,44.64 73.83,47.02 79.73,47.02 82.77,50.06 87.14,50.06 90.45,53.37 97.12,53.37 v2(97.24,53.24)
VCCIN_EN: length 10.4
  TOP w0.203: U10.23 178.67,56.08 178.24,56.51 178.24,56.87 v2(178.19,56.92) ; D39.2 174.33,58.32 174.46,58.19 R114.2 174.94,57.94 v2(175.48,58.47)
  BOTTOM w0.114: R27125.2 177.82,57.68 177.9,57.59 177.9,57.22 v2(178.19,56.92) 178.22,56.9 178.22,56.42 178.13,56.33 C27102.2 R91326.1 R110.2
  BOTTOM w0.203: v2(175.48,58.47) 176.27,57.68 R27124.2 R27125.2
VCCIN_VIDALERT_N: length 9.7
  TOP w0.089: U1JSL.AD3 123.96,72.44 124.3,72.77 124.3,73 124.1,73.2 124.1,73.6 124.18,73.68 124.18,74.4 124.57,74.8
  TOP w0.109: 124.57,74.8 124.57,77.12 124.96,77.51 R3F3.2 124.53,78.83 124.53,79.6 v4(124.91,79.98) 124.96,80.03 R3F13.1
VCCIN_VIDSCK: length 9.1
  TOP w0.089: U1JSL.AA2 124.84,73.48 125.23,73.87 125.23,74.58
  TOP w0.109: 125.23,74.58 125.23,76.28 125.75,76.8 125.75,78.04 125.9,78.19 126.2,78.19 126.43,78.42 126.43,79.59 v4(126.74,79.89) 126.41,80.23 126.33,80.23 125.96,80.6 R2F3.1
VCCIN_VIDSOUT: length 8.6
  TOP w0.109: R2F14.1 123.85,80.6 124.27,80.17 124.27,79.04 123.85,78.62 R3F4.2 123.84,78.08 124.13,77.79 v4(124.13,77.74) 124.13,76.89 124.35,76.67 124.35,74.87 123.99,74.51 123.99,73.78 123.87,73.66 123.85,73.61 123.85,72.99 U1JSL.AC2
VCCIO_EXT_G0: length 3.8
  TOP w0.114: U38.10 162.76,73.83 162.9,73.69 R449.1 162.67,73.43 162.46,73.21 162.46,73.14 v4(162.15,72.83) 162.46,72.52 162.46,72.33 162.46,72.33 162.46,72.24 162.69,72.01 R448.2
VCCIO_EXT_G1: length 4.7
  TOP w0.109: v4(164.84,71.28) 164.53,71.59 164.53,71.77 164.29,72.01 R450.2
  TOP w0.114: U38.11 163.16,73.78 163.51,73.43 R451.1 163.86,73.43 164.05,73.24 164.05,72.01 R450.2
VCCIO_EXT_LGATE:
  vias: v4(160.79,74.68)
VCCIO_EXT_MODE: length 2.4
  TOP w0.109: U38.1 164.36,77.75 164.86,78.25 R457.2 165.26,78.58 165.29,78.6 v4(165.72,78.6)
VCCIO_EXT_PHASE:
  vias: v4(153.32,75)
VCCIO_EXT_RGND: length 57.1
  TOP w0.109: v2(168.58,80.03) 168.58,76.94 168.16,76.52 167.03,76.52 165.72,75.21 165.72,73.82 165.31,73.42 165.31,72.44 164.94,72.07 164.61,72.07 ; R461.1 128.14,81.74 v2(128.03,81.85)
  TOP w0.114: U38.12 163.56,74.14 164.31,73.39 164.31,72.38 164.61,72.07
  IN2 w0.097: v2(168.58,80.03) 166.66,81.95 148.38,81.95 147.25,83.08 144.39,83.08 143.71,82.4 137.66,82.4 136.71,81.45 130.09,81.45 129.69,81.85 v2(128.03,81.85)
VCCIO_EXT_UGATE:
  vias: v4(158.26,79.95)
VCCIO_EXT_UGATE_R: length 4.9
  TOP w0.203: v2(162.45,78.24) 162.45,78.14 162.36,78.05 U38.6
  TOP w0.508: R460.1 160.24,79.62 v4(160.24,78.67)
  IN1 w0.508: v2(162.45,78.24) 161.87,78.24 161.44,78.67 v4(160.24,78.67)
VCCIO_SNS_P: length 41.9
  TOP w0.203: U38.13 163.96,74.28 164.11,74.13 v2(165.04,74.13) ; v2(139.46,73.77) R1014.2
  IN1 w0.203: v2(139.46,73.77) 139.46,77.23 145.32,83.08 146.27,83.08 149.24,80.11 165.08,80.11 165.37,79.82 165.37,77.28 164.55,76.46 164.55,74.62 v2(165.04,74.13)
VCCIO_SNS_R_P: length 1.4
  TOP w0.203: R1014.1 139.46,72.17 v2(139.72,71.92)
  TOP w0.254: U1JSL.AJ12 v2(121.6,68.85)
VCCST_OVERRIDE: length 77.9
  TOP w0.089: U1JSL.AP2 118.88,73.6 118.76,73.73 118.76,74.18 118.58,74.36 118.58,75.16 119.14,75.72 119.14,77.28 119.1,77.32 119.1,77.62
  TOP w0.109: v2(76.37,75.18) 75.89,74.7 73.78,74.7 67.98,68.9 61.23,68.9 60.85,68.51 60.85,67.88 60.91,67.82 Q25.2 ; 119.1,77.62 119.1,77.72 118.59,78.23 118.59,78.72 118.13,79.18 118.13,80.67 117.63,81.16 117.06,81.16 115.77,82.46 111.8,82.46 111.65,82.61 v2(111.65,84.77)
  IN4 w0.089: v2(111.65,84.77) 111.18,84.77 109.84,83.44 103.36,83.44 103.03,83.77 94.91,83.77 93.46,82.32 87.5,82.32 84.35,79.17 78.75,79.17 76.47,76.9 76.47,75.28 v2(76.37,75.18)
VCCST_PWRGD_R: length 71.9
  TOP w0.089: 119.34,77.62 119.32,77.61 119.32,75.65 118.76,75.09 118.76,74.43 118.94,74.24 118.94,73.96 119.06,73.85 119.06,73.14 119.15,73.04 119.15,72.69 118.88,72.42 U1JSL.AP4
  TOP w0.109: v2(113.4,84.77) 113.18,84.54 113.18,83.49 R8608.1 113.46,82.71 115.89,82.71 117.21,81.4 117.73,81.4 118.36,80.77 118.36,79.28 118.83,78.82 118.83,78.33 119.34,77.82 119.34,77.62 ; v2(75.61,74.28) 73.73,74.28 67.46,68.01 D35.2
  IN2 w0.097: v2(113.4,84.77) 112.92,84.29 110.81,84.29 108.46,81.95 95.28,81.95 93.76,80.42 88.21,80.42 84.63,76.84 83.16,76.84 82.57,76.25 78.91,76.25 76.94,74.28 v2(75.61,74.28)
ACCEL_INT_L: length 1.7
  TOP w0.109: v2(191.93,80.5) 191.92,80.51 TP116.1
  BOTTOM w0.114: J24.3 v2(191.93,80.5)
ACOK_OD: length 110.8
  TOP w0.079: U13.A6 163.25,21.6 163.18,21.67 163.04,21.67 v1(162.68,22.03) 162.3,22.41 162.01,22.41
  TOP w0.109: 162.01,22.41 161.88,22.41 161.72,22.26 R74.2
  IN2 w0.097: v1(162.68,22.03) 159.88,19.23 158.87,19.23 157.3,17.67 155.51,17.67 155.34,17.84 151.05,17.84 150.31,17.11 146.66,17.11 143.57,14.01 114.2,14.01 110.41,17.8 106.02,17.8 105.54,17.32 103.29,17.32 102.89,16.92 102.89,15.98 102.08,15.16 94.23,15.16 93.62,15.77 93.62,16.76 93.3,17.08 92.09,17.08 91.65,16.64 78.56,16.64 77.52,17.68 68.09,17.68 v2(67.54,18.22)
  BOTTOM w0.114: R1013.2 65.66,21.14 66.72,20.08 66.72,19.04 v2(67.54,18.22)
ALL_SYS_PWRGD: length 65.5
  TOP w0.079: 156.99,28.73 156.99,28.38 156.49,27.87 U17.L12
  TOP w0.109: v1(155.75,30.52) 155.75,30.14 v4(156.02,29.86) 156.99,28.89 156.99,28.73
  IN1 w0.114: v2(183.17,43.26) 183.17,42.12 184.42,40.87 184.42,34.61 184,34.19 182.67,34.19 182.33,33.84 166.84,33.84 166.2,33.2 166.2,32.68 165.72,32.2 163.19,32.2 162.2,31.2 156.2,31.2 155.75,30.74 v1(155.75,30.52)
  IN2 w0.097: v2(176.17,59.5) 178.2,57.47 179.72,57.47 181.88,55.31 181.88,51.37 182.39,50.86 182.39,43.8 182.92,43.26 v2(183.17,43.26)
  BOTTOM w0.114: R27125.1 176.34,59.5 v2(176.17,59.5)
AP_BATLOW_L: length 18.9
  TOP w0.089: R8702.2 95.31,45.37 95.75,44.93 97.89,44.93 98.49,44.33 99.6,44.33 99.83,44.56 v4(100.22,44.56) 100.73,44.56 100.96,44.33 103.62,44.33 108,48.72 108,50.46 107.96,50.51 107.96,50.89 108.03,50.96 108.03,51.28 107.91,51.47 107.91,51.76 107.72,52.23 U1JSL.BW48
AP_DPWROK: length 29.8
  TOP w0.089: 105.1,44.01 105.1,44.23 109.07,48.21 109.07,48.73 109.83,49.49 109.83,50.86 109.68,51.08 109.68,51.2 109.77,51.37 109.78,51.39 109.85,51.54 U1JSL.BP49
  TOP w0.117: v2(93.62,43.72) 93.82,43.72 v4(94.14,43.4) 94.39,43.16 104.25,43.16 105.1,44.01
  BOTTOM w0.117: D22.2 88.84,42.83 89.08,42.58 90.45,42.58 90.7,42.83 90.7,43.77 91.2,44.27 D38.1 91.46,44.38 92.36,45.27 92.87,45.27 93.02,45.12 R468.2 R368.1 93.25,44.1 v2(93.62,43.72)
AP_EDP_BKLTEN: length 64
  TOP w0.089: U1JSL.CB17 106.43,66.39 106.2,66.62 v1(106.2,66.76)
  IN1 w0.097: v2(51.81,57.29) 52.09,57.57 52.09,58.85 54.34,61.1 55.03,61.1 55.67,61.73 60.85,61.73 61.41,62.29 64.94,62.29 66.08,61.15 75.41,61.15 77.4,63.14 77.4,63.83 79.82,66.24 85.94,66.24 86.73,67.04 90.11,67.04 v2(90.59,67.52)
  BOTTOM w0.089: 101.31,67.55 102.03,67.55 102.45,67.12 105.43,67.12 105.8,67.49 R23.1 106.08,66.88 v1(106.2,66.76)
  BOTTOM w0.114: 101.31,67.55 100.91,67.55 100.41,68.05 97.64,68.05 v4(97.43,68.25) 97.43,68.23 97.28,68.07 95.2,68.07 94.99,68.29 92.32,68.29 91.97,67.93 90.9,67.93 90.59,67.63 v2(90.59,67.52) ; D23.1 52.22,57.69 v2(51.81,57.29)
AP_FLASH_HOLD_L: length 18.7
  TOP w0.109: U1.14 168.38,28.84 168.29,28.93 168.29,29.63 v2(168.65,29.99)
  BOTTOM w0.114: v2(168.65,29.99) 168.65,27.56 169.12,27.1 169.12,26.75 169.51,26.35 169.51,24.5 173.51,20.5 175.42,20.5 175.63,20.71 175.63,21.88 175.5,22.02 R59.2 175.2,22.31 175.11,22.4 U11.7
AP_FLASH_WP_ODL: length 14
  TOP w0.109: v2(177.79,31.1) 177.36,30.67 176.93,30.67 176.68,30.92 176.68,31.35 176.12,31.91 170.57,31.91 170.35,31.7 R153.2 170.07,31.51 169.92,31.66 v4(169.49,31.66) 168.64,31.66 168.36,31.38 D20.2
  BOTTOM w0.114: U11.3 176.38,29.69 v2(177.79,31.1)
AP_I2C_AUDIO_SCL: length 136.9
  TOP w0.089: U1JSL.CH24 v2(103.49,62.52)
  TOP w0.109: v2(26.82,30.69) 26.69,30.81 26.11,30.81 24.61,32.32 24.11,32.32 R91336.1 ; v2(18.03,17.26) 17.93,17.36 R91330.1 ; R91333.1 20.69,9.28 v2(20.67,9.26)
  IN1 w0.097: v2(26.82,30.69) 26.98,30.85 27.22,30.85 27.6,31.23 27.6,31.68 31.85,35.93 45.5,35.93 50.13,40.56 61.06,40.56 62.6,42.1 71.41,42.1 73.55,44.24 73.55,46.67 73.93,47.05 73.93,47.82 74.77,48.67 75.67,48.67 77.23,50.23 77.23,52.15 82.88,57.8 86.45,57.8 86.79,57.45 87.61,57.45 87.76,57.29 92.3,57.29 92.99,57.98 94.97,57.98 95.27,57.67 95.88,57.67 96.42,57.14 97.45,57.14 97.86,57.54 100.74,57.54 102.33,59.14 102.33,61.13 103.29,62.1 103.29,62.33 v2(103.49,62.52)
  IN4 w0.089: v2(26.82,30.69) 26.7,30.81 24.83,30.81 21.33,27.31 18.76,27.31 17.87,26.42 17.87,23.45 16.03,21.61 16.03,20.24 17.87,18.4 17.87,17.42 v2(18.03,17.26) 17.87,17.1 17.87,15.99 19.37,14.49 19.37,10.78 19.65,10.5 20.01,10.5 20.67,9.84 v2(20.67,9.26)
  BOTTOM w0.109: R330.2 100.07,61.91 101.29,63.13 102.83,63.13 103.09,62.87 103.14,62.87 v2(103.49,62.52)
AP_I2C_AUDIO_SDA: length 136.8
  TOP w0.089: U1JSL.CJ24 v2(102.83,62.52)
  TOP w0.109: R91331.1 17.21,17.44 v2(17.39,17.26) ; v2(20.08,9.26) 20.16,9.33 20.16,9.57 R91334.1 ; v2(26.8,31.27) 26.63,31.1 26.23,31.1 24.73,32.61 24.11,32.61 R91335.1
  IN1 w0.097: v2(102.83,62.52) 103.02,62.33 103.02,62.21 102.05,61.25 102.05,59.25 100.62,57.82 97.75,57.82 97.34,57.41 96.53,57.41 95.99,57.95 95.38,57.95 95.08,58.25 92.87,58.25 92.19,57.57 87.88,57.57 87.72,57.72 86.91,57.72 86.56,58.07 82.76,58.07 76.96,52.27 76.96,50.34 75.56,48.94 74.66,48.94 73.65,47.93 73.65,47.16 73.28,46.78 73.28,44.36 71.29,42.37 62.48,42.37 60.95,40.84 50.02,40.84 45.38,36.21 31.73,36.21 27.32,31.8 27.32,31.34 27.11,31.13 26.95,31.13 v2(26.8,31.27)
  IN4 w0.089: v2(20.08,9.26) 20.4,9.57 20.4,9.73 19.9,10.23 19.54,10.23 19.11,10.67 19.11,14.38 17.6,15.88 17.6,17.05 v2(17.39,17.26) 17.6,17.47 17.6,18.29 15.77,20.13 15.77,21.72 17.6,23.56 17.6,26.53 18.65,27.58 21.22,27.58 24.72,31.07 26.6,31.07 v2(26.8,31.27)
  BOTTOM w0.109: R329.2 99.3,61.35 99.58,61.63 100.19,61.63 101.41,62.85 102.71,62.85 102.83,62.73 v2(102.83,62.52)
AP_I2C_CAM_SCL: length 9.3
  TOP w0.089: v2(104.73,62.57) 104.74,62.58 104.74,62.71 U1JSL.CF24
  BOTTOM w0.109: R328.2 97.3,62.27 99.92,62.27 101.13,63.48 103.67,63.48 104.07,63.07 TP131.1 104.27,62.88 104.47,62.68 104.62,62.68 v2(104.73,62.57)
AP_I2C_CAM_SDA: length 10.1
  TOP w0.089: v1(105.42,63.32) 105.45,63.32 U1JSL.CC24
  BOTTOM w0.109: v1(105.42,63.32) 105.06,62.96 104.59,62.96 103.78,63.77 100.83,63.77 TP132.1 100.31,63.25 100.31,63.07 99.8,62.56 97.21,62.56 R327.2
AP_I2C_EMR_SCL: length 9.4
  TOP w0.089: U1JSL.CR9 100.38,69.84 100.13,69.96 99.34,69.96 99.12,70.18 ; v2(96.41,71.92) 96.33,71.83 R324.2
  TOP w0.109: v2(96.41,71.92) 96.69,72.2 97.1,72.2 99.12,70.18
  BOTTOM w0.109: TP119.1 98.32,70.92 97.97,71.28 97.97,71.75 97.24,72.48 96.83,72.48 96.53,72.19 96.53,72.04 v2(96.41,71.92)
AP_I2C_EMR_SDA: length 8.6
  TOP w0.089: U1JSL.CP10 100.62,69.53 100.09,69.78 99.24,69.78 99.04,69.98
  TOP w0.109: R316.2 95.97,71.27 96.23,71.54 96.77,71.54 v2(97,71.77) 97.25,71.77 99.04,69.98
  BOTTOM w0.109: v2(97,71.77) 96.82,71.94 96.82,72.07 96.95,72.2 97.12,72.2 97.68,71.63 97.68,71.18 TP118.1
AP_I2C_SUB_INT_ODL: length 3.5
  TOP w0.089: 99.8,71.17 100.29,71.17 U1JSL.CP6
  TOP w0.109: v2(98.41,72.14) 99,71.54 99.02,71.54 99.39,71.17 99.8,71.17
  BOTTOM w0.114: TP97.1 98.46,72.19 v2(98.41,72.14)
AP_I2C_SUB_SCL: length 13.3
  TOP w0.089: U1JSL.CB21 106.46,64.92 v1(106.57,65.04)
  BOTTOM w0.089: 100.98,64.67 101.01,64.67 101.06,64.72 101.28,64.72 101.5,64.94 101.67,64.94 101.85,64.94 102.05,64.73 103.04,64.73 103.2,64.57 103.2,64.57 103.29,64.49 106.13,64.49 106.33,64.68 106.33,64.79 v1(106.57,65.04)
  BOTTOM w0.109: R11.2 95.17,63.67 95.24,63.74 R1030.2 96.41,63.74 TP95.1 96.89,63.96 99.12,63.96 99.36,64.21 99.83,64.21 100.29,64.67 100.98,64.67
AP_I2C_SUB_SDA: length 13.2
  TOP w0.089: v1(106.03,65.09) 106.43,65.49 U1JSL.CB19
  BOTTOM w0.089: 100.98,64.95 101.01,64.95 101.06,64.9 101.21,64.9 101.42,65.11 101.74,65.11 101.92,65.11 102.12,64.91 103.11,64.91 103.28,64.75 103.28,64.75 103.36,64.67 106.06,64.67 106.15,64.76 106.15,64.97 v1(106.03,65.09)
  BOTTOM w0.109: 100.98,64.95 100.17,64.95 99.71,64.49 99.24,64.49 99,64.25 97.17,64.25 TP96.1 96.52,64.86 R1029.2 95.32,64.86 95.04,65.14 R2.2
AP_I2C_TRACKPAD_SCL_3V3: length 170.9
  TOP w0.089: U1JSL.CJ11 103.25,69.26 v1(102.98,69.53)
  IN1 w0.097: v2(161.73,26.16) 161.54,25.97 161.54,25.74 161.94,25.33 163.94,25.33 164.36,24.91 167.13,24.91 167.65,24.39 169.12,24.39 169.72,23.8 172.49,23.8 173.45,24.76 173.84,24.76 174.34,25.26 174.34,27.11 175.1,27.87 179.72,27.87 180.49,28.63 181.04,28.63 181.19,28.78 181.19,28.94 v2(181.03,29.09)
  IN2 w0.097: v1(102.98,69.53) 103.24,69.8 103.24,69.84 103.69,70.29 103.69,70.9 103.25,71.33 103.25,72.17 104.95,73.87 108.8,73.87 109.37,74.44 118.41,74.44 118.98,73.87 129.04,73.87 129.97,74.8 132.78,74.8 133.21,75.23 135.2,75.23 136.43,76.47 139.51,76.47 144.52,81.47 165.89,81.47 167.83,79.53 176.33,79.53 185.87,70 185.87,54.13 186,54 186.28,54 v2(186.44,54.16)
  IN4 w0.089: v2(186.44,54.16) 186.21,53.93 185.77,53.93 185.11,53.27 185.11,52.76 183.85,51.5 183.85,47.95 182.33,46.44 182.33,42.76 184.37,40.72 184.37,38.58 184.82,38.14 184.82,32.87 181.04,29.09 v2(181.03,29.09)
  BOTTOM w0.089: v1(102.98,69.53) 102.74,69.29 102.53,69.29 102.39,69.44 R144.2
  BOTTOM w0.109: J18.4 160.65,23.3 160.55,23.4 160.55,23.58 160.98,24.01 160.98,25.22 161.53,25.77 161.53,25.96 v2(161.73,26.16)
AP_I2C_TRACKPAD_SDA_3V3: length 171.1
  TOP w0.089: v1(103.52,69.53) 103.91,69.15 U1JSL.CH11
  IN1 w0.097: v2(161.08,26.14) 161.1,26.14 161.27,25.97 161.27,25.62 161.83,25.06 163.82,25.06 164.24,24.64 167.02,24.64 167.54,24.12 169.01,24.12 169.6,23.52 172.6,23.52 173.57,24.49 173.95,24.49 174.61,25.15 174.61,26.99 175.21,27.6 179.84,27.6 180.6,28.36 181.16,28.36 181.46,28.66 181.46,28.92 v2(181.63,29.08)
  IN2 w0.097: v2(186.44,53.51) 186.23,53.72 185.89,53.72 185.6,54.02 185.6,69.88 176.22,79.26 167.72,79.26 165.78,81.2 144.64,81.2 139.63,76.19 136.55,76.19 135.31,74.95 133.32,74.95 132.89,74.52 130.08,74.52 129.16,73.6 118.87,73.6 118.3,74.17 109.48,74.17 108.91,73.6 105.06,73.6 103.52,72.06 103.52,71.45 103.96,71.01 103.96,70.17 103.52,69.73 v1(103.52,69.53)
  IN4 w0.089: v2(186.44,53.51) 186.29,53.66 185.88,53.66 185.37,53.16 185.37,52.65 184.11,51.38 184.11,47.84 182.6,46.33 182.6,42.87 184.64,40.83 184.64,38.7 185.08,38.25 185.08,32.76 181.63,29.31 v2(181.63,29.08)
  BOTTOM w0.089: v1(103.52,69.53) 103.47,69.53 103.06,69.11 102.51,69.11 R103.2
  BOTTOM w0.109: J18.5 160.15,23.24 160.26,23.35 160.26,23.7 160.69,24.13 160.69,25.34 161.24,25.89 161.24,26 161.1,26.14 v2(161.08,26.14)
AP_I2C_TS_SCL: length 71.5
  TOP w0.089: U1JSL.CL25 101.95,62.86 101.67,62.86 101.46,62.65 101.37,62.61 101.33,62.59 100.99,62.59 100.79,62.47 100.55,62.47 100.39,62.54 100.01,62.54 99.58,62.1 98.21,62.1 98.03,61.92 98.03,61.77 v2(97.8,61.55)
  IN1 w0.097: v2(97.8,61.55) 97.98,61.72 97.98,62 98.3,62.31 99.57,62.31 100.73,61.15 100.73,59.62 99.13,58.02 97.04,58.02 96.22,58.84 94.87,58.84 94.67,58.64 92.63,58.64 91.94,57.95 88.02,57.95 87.89,58.08 87.05,58.08 86.69,58.44 84.84,58.44 84.15,59.13 82.99,59.13 80.98,57.11 79.63,57.11 75.02,52.51 73.78,52.51 71.95,50.68 62.14,50.68 v2(61.49,50.02)
  BOTTOM w0.109: R326.2 96.59,61.3 97.74,61.3 97.8,61.37 v2(97.8,61.55) ; J23.37 59.75,60.94 59.64,60.84 59.64,60.74 59.75,60.64 61.74,60.64 62.5,59.88 62.5,51.73 61.92,51.14 61.92,50.46 v2(61.49,50.02)
AP_I2C_TS_SDA: length 69.1
  TOP w0.089: v2(98.39,61.55) 98.21,61.73 98.21,61.85 98.28,61.93 99.65,61.93 100.08,62.36 100.35,62.36 100.52,62.29 100.84,62.29 101.04,62.41 101.36,62.41 U1JSL.CM25
  IN1 w0.097: v2(98.39,61.55) 98.26,61.68 98.26,61.88 98.41,62.04 99.45,62.04 100.45,61.04 100.45,59.74 99.02,58.3 97.15,58.3 96.33,59.12 94.76,59.12 94.56,58.91 92.52,58.91 91.83,58.22 88.13,58.22 88,58.35 87.16,58.35 86.8,58.72 84.95,58.72 84.26,59.41 82.88,59.41 80.86,57.39 79.51,57.39 74.91,52.79 73.67,52.79 71.83,50.95 62.03,50.95 61.68,50.6 61.54,50.6 v2(61.49,50.66)
  BOTTOM w0.109: R325.2 96.51,60.66 96.86,61.02 97.86,61.02 v2(98.39,61.55) ; J23.36 59.25,60.95 59.36,60.84 59.36,60.62 59.63,60.35 61.63,60.35 62.22,59.76 62.22,51.84 61.63,51.26 61.63,50.8 v2(61.49,50.66)
AP_PEN_DET_ODL: length 19.4
  TOP w0.089: U1JSL.CC13 106.22,68.19 v1(106.65,68.62)
  TOP w0.109: D32.2 90.58,70.2 91.04,69.75 v2(91.04,69.51)
  BOTTOM w0.089: 101,68.52 101.32,68.21 104.26,68.21 104.48,68.43 104.48,68.78 104.73,69.03 105.94,69.03
  BOTTOM w0.114: 105.94,69.03 106.02,69.03 R91342.2 106.27,68.99 v1(106.65,68.62)
  BOTTOM w0.117: 101,68.52 100.51,69.02 100.4,69.02 99.91,69.51 97.83,69.51 97.51,69.19 96.6,69.19 96.5,69.29 v4(94.83,69.29) 94.47,69.29 94.25,69.51 92.5,69.51 92.27,69.73 91.27,69.73 v2(91.04,69.51)
AP_PROCHOT_ODL: length 11.7
  TOP w0.089: 123.29,77.62 123.49,77.42 123.49,76.3 123.62,76.17 123.62,73.94 123.33,73.64 123.33,73.13 123.41,73.05 123.41,72.69 123.29,72.57 123.29,72.32 123.48,72.13 123.88,72.13 U1JSL.AC4
  TOP w0.109: 123.29,77.62 123.12,77.8 123.12,81.46 122.32,82.25 R8606.1
AP_RSMRST_L: length 25.7
  TOP w0.089: v4(94.93,44.4) 95.4,44.4 96.01,43.79 103.86,43.79 108.54,48.47 108.54,50.09 108.81,50.36 108.81,50.81 108.96,51 108.96,51.18 108.77,51.48 U1JSL.BU49
  TOP w0.109: 94.9,44.43 v4(94.93,44.4)
  TOP w0.117: 94.9,44.43 94.65,44.43 94.4,44.68 92.62,44.68 R340.1 RB6B1.2 91.09,45.01 90.96,45.15 D34.2 90.39,44.53 v2(90.49,44.43)
  BOTTOM w0.117: D38.2 90.34,44.27 v2(90.49,44.43)
AP_SLP_A_L: length 10.2
  TOP w0.089: U1JSL.CB49 106.35,51.48 106.37,51.45 106.54,51.18 106.54,51 106.39,50.81 106.39,50.38 106.18,50.16 106.18,48.66 104.02,46.51 102.83,46.51 102.62,46.31 101.25,46.31 v4(101.11,46.44) 100.92,46.25 R11103.1
AP_SLP_S0_L: length 8.8
  TOP w0.089: U1JSL.CN41 101.06,55.82 100.86,55.96 100.22,55.96 100.14,55.88 99.78,55.88
  TOP w0.109: 99.78,55.88 97.98,55.88 97.63,55.53 R11108.1 96.58,55.73 96.41,55.91 94.75,55.91 v4(94.63,55.79) 94.35,55.79 93.81,55.24 R39.2
AP_SLP_S3_L: length 15.1
  TOP w0.089: U1JSL.CB47 106.64,52.5 106.64,51.67 106.61,51.6 106.61,51.41 106.72,51.23 106.72,51.18 106.72,50.94 106.72,50.94 106.59,50.77 106.59,50.77 106.57,50.75 106.57,50.31 106.36,50.09 106.36,48.59 104.1,46.33 102.9,46.33 102.7,46.13 101.62,46.13 101.53,46.04 100.71,46.04 100.55,45.87 98.71,45.87 98.42,46.17 R11111.1 v4(97.73,46.25) R18.2
AP_SLP_S4_L: length 18.3
  TOP w0.089: U1JSL.BW47 107.45,52.65 107.45,52.12 107.64,51.93 107.68,51.84 107.73,51.72 107.73,51.42 107.85,51.23 107.85,51.03 107.78,50.96 107.78,50.44 107.82,50.39 107.82,48.79 103.54,44.51 101.26,44.51 100.7,45.07 99.86,45.07 99.53,44.74 v4(98.94,44.74) 98.56,45.11 97.12,45.11 96.89,45.34 R11110.1 96.53,45.44 96.46,45.37 R19.2
AP_SLP_S5_L: length 7.6
  TOP w0.089: U1JSL.BW51 107.6,51.09 107.6,50.36 107.65,50.32 107.65,48.87 104.14,45.37 TP61.1
AP_SLP_SUS_L: length 20.3
  TOP w0.089: 94.31,45.01 94.42,45.01 94.63,44.81 95.14,44.81 95.36,44.58 95.7,44.58 95.97,44.31 v4(96.36,44.31) 96.7,43.97 103.79,43.97 108.36,48.54 108.36,50.16 108.63,50.44 108.63,51.06 U1JSL.BU51
  TOP w0.117: 94.31,45.01 R11109.1 R10.2
AP_SLP_WLAN_L: length 9.4
  TOP w0.089: TP60.1 103.06,45.98 104.24,45.98 107.29,49.02 107.29,50.17 107.25,50.21 107.25,50.79 107.11,50.99 107.11,51.29 107.18,51.43 107.18,51.52 U1JSL.CA48
AP_SPI_FLASH_CLK: length 138.4
  IN4 w0.089: v2(177.6,22.2) 176.79,22.2 173.82,25.17 173.82,26.12 172.39,27.55 172.39,28.22 170.1,30.51 168.24,30.51 167.62,31.13 165.19,31.81 163.72,31.81 162.57,32.5 161.33,33.54 150.21,33.54 146.13,29.46 144.86,29.46 139.73,24.33 121.58,24.33 121.37,24.13 106.8,24.13 106.34,24.59 97.89,24.59 95.38,26.12 92.84,26.9 90.83,27.56 89.72,28.67 88.5,30.8 88.5,37.69 88.3,37.89 88.3,44.51 88.51,46.38 90.34,48.22 91.63,48.74 93.36,48.74 93.47,48.63 96.53,48.63 99.83,51.93 99.83,54.24 101.28,55.69 v1(101.72,55.69)
  BOTTOM w0.109: v1(101.72,55.69) 102.13,56.1 R150.1 ; U11.6 176.38,22.41 176.28,22.31 R54.2 R78.2 177.42,22.02 v2(177.6,22.2)
AP_SPI_FLASH_CLK_R: length 3.7
  TOP w0.089: U1JSL.CH34 103.52,58.17 v1(103.52,58.05)
  BOTTOM w0.109: v4(101.31,56.63) R150.2 102.43,56.63 102.73,56.93 R11112.1 103.07,57.29 103.52,57.75 v1(103.52,58.05)
AP_SPI_FLASH_CS_L: length 148.6
  TOP w0.109: R76.1 174.97,30.75 175.35,30.36 175.35,29.93 175.49,29.79 175.62,29.79 175.79,29.96 175.79,30.45 175.87,30.54 176.04,30.54 176.17,30.67 v2(176.17,31.15)
  IN4 w0.089: v2(176.17,31.15) 176.17,32.57 175.57,33.17 175.45,33.17 174.94,32.66 174.81,32.66 174.66,32.81 174.66,32.94 175.17,33.45 175.17,33.57 175.01,33.73 174.89,33.73 174.38,33.22 174.25,33.22 174.1,33.37 174.1,33.5 174.61,34.01 174.61,34.13 174.39,34.35 172.93,34.35 172.84,34.26 172.84,34.06 172.75,33.97 172.54,33.97 172.45,34.06 172.45,34.26 172.36,34.35 172.14,34.35 172.05,34.26 172.05,34.06 171.96,33.97 171.75,33.97 171.66,34.06 171.66,34.26 171.57,34.35 168.89,34.35 168.8,34.26 168.8,34.06 168.71,33.97 168.49,33.97 168.41,34.06 168.41,34.26 168.32,34.35 168.1,34.35 168.01,34.26 168.01,34.06 167.92,33.97 167.71,33.97 167.62,34.06 167.62,34.26 167.53,34.35 167.31,34.35 167.22,34.26 167.22,34.06 167.14,33.97 166.92,33.97 166.83,34.06 166.83,34.26 166.74,34.35 166.53,34.35 166.44,34.26 166.44,34.06 166.35,33.97 166.13,33.97 166.04,34.06 166.04,34.26 165.95,34.35 165.74,34.35 165.65,34.26 165.65,34.06 165.56,33.97 165.35,33.97 165.26,34.06 165.26,34.26 165.17,34.35 164.95,34.35 164.86,34.26 164.86,34.06 164.77,33.97 164.56,33.97 164.47,34.06 164.47,34.26 164.38,34.35 164.16,34.35 164.08,34.26 164.08,34.06 163.99,33.97 163.77,33.97 163.68,34.06 163.68,34.26 163.59,34.35 149.87,34.35 145.91,30.39 144.64,30.39 139.39,25.14 121.24,25.14 121.04,24.94 107.14,24.94 106.68,25.4 98.99,25.4 95.14,27.7 93.28,27.7 91.71,29.27 91.38,29.27 89.31,31.34 89.31,38.68 89.11,38.88 89.11,43.5 89.43,43.81 89.43,46.15 90.68,47.4 93.21,47.4 93.53,47.73 96.78,47.73 100.64,51.59 100.64,53.9 101.54,54.8 101.87,54.8 102.55,55.48 102.55,55.53 102.84,55.81 103.01,55.81 v2(103.5,56.3)
  BOTTOM w0.109: R50.1 104.11,56.91 v2(103.5,56.3) ; v2(176.17,31.15) 175.65,31.15 175.44,31.35 R58.2 174.84,31.67 174.68,31.51 R313.2 173.83,30.72 173.91,30.64 173.91,30.03 173.84,29.97 U11.1
AP_SPI_FLASH_CS_L_R: length 1.5
  TOP w0.089: U1JSL.CE34 v2(104.81,58.01)
  BOTTOM w0.109: R50.2 104.16,57.37 v2(104.81,58.01)
AP_SPI_FLASH_MISO: length 140.8
  TOP w0.089: v1(102.76,58.08) 102.79,58.05 102.79,57.93 U1JSL.CJ36
  IN4 w0.089: v1(102.76,58.08) 103.25,57.59 104.16,57.59 105.17,56.58 105.17,56.07 104.92,55.81 103.88,55.81 102.89,54.82 102.89,54.72 102.49,54.33 102.29,54.33 101.87,53.91 101.29,53.91 100.98,53.61 100.98,51.45 96.92,47.38 93.67,47.38 93.35,47.06 90.82,47.06 89.88,46.13 89.88,44.18 90.57,43.5 90.57,42.26 89.58,41.26 89.58,38.9 89.65,38.82 89.65,31.48 91.48,29.65 91.81,29.65 93.42,28.04 95.33,28.04 99.13,25.74 106.82,25.74 107.28,25.28 120.89,25.28 121.1,25.49 139.25,25.49 144.64,30.88 145.91,30.88 149.73,34.69 174.81,34.69 176.16,33.34 176.29,33.34 176.8,33.85 176.92,33.85 177.13,33.65 177.13,33.52 176.62,33.01 176.62,32.88 176.83,32.68 176.95,32.68 177.46,33.19 177.59,33.19 177.79,32.98 177.79,32.85 177.28,32.35 177.28,32.22 v2(178.38,31.13)
  BOTTOM w0.109: R56.1 178.18,31.66 178.38,31.47 v2(178.38,31.13)
AP_SPI_FLASH_MISO_R: length 5.3
  BOTTOM w0.109: R56.2 177.5,32.02 177.4,32.12 R77.1 176.89,32.12 176.44,31.67 R53.2 176.33,31.58 176.6,31.32 176.6,30.87 v4(176.68,30.8) 176.52,30.64 176.1,30.64 175.11,29.65 U11.2
AP_SPI_FLASH_MOSI: length 141.1
  IN4 w0.089: v2(178.68,22.68) 174.91,25.94 173.77,27.15 172.78,28.72 170.5,31 169.76,31.53 165.94,32.24 163.69,32.45 161.53,34.01 150.01,34.01 145.96,29.96 144.69,29.96 139.54,24.8 121.38,24.8 121.18,24.6 106.99,24.6 106.54,25.06 98.64,25.06 95.71,26.68 94.66,26.85 93.1,27.33 90.97,28.11 90.12,28.95 88.97,30.92 88.97,38.54 88.77,38.74 88.77,43.85 88.99,46.2 90.52,47.73 91.64,48.19 93.11,48.19 93.24,48.07 96.63,48.07 100.3,51.73 100.3,54.04 101.4,55.14 101.73,55.14 102.09,55.5 102.38,56.45 102.63,56.7 103.61,56.7 v2(104.16,56.27)
  BOTTOM w0.109: v2(104.16,56.27) 104.8,56.91 R151.1 ; v2(178.68,22.68) 178.68,22.55 179,22.22 R79.2 R57.2 178.22,22.31 177.65,22.88 U11.5
AP_SPI_FLASH_MOSI_R: length 1.4
  TOP w0.089: U1JSL.CC34 v2(105.47,58.01)
  BOTTOM w0.109: v2(105.47,58.01) 104.92,57.47 R151.2
AP_SPI_H1_TPM_CLK: length 124.2
  TOP w0.079: U13.F9 166,23.5 166.13,23.64 v1(166.13,24.19)
  TOP w0.117: R390.2 94.22,56.67 94.18,56.63 v2(94.13,56.63)
  IN4 w0.089: v1(166.13,24.19) 166.13,25.89 165.05,26.97 165.05,28.21 163.94,29.32 163.73,29.32 160.8,32.26 151.16,32.26 147.07,28.17 145.82,28.17 141.55,23.9 141.55,23.59 140.55,22.58 126.33,22.58 126.13,22.78 114.74,22.78 114.37,22.41 106.7,22.41 105.81,23.3 95.82,23.3 94.54,24.59 91.99,24.59 87.22,29.36 87.22,37.15 87.01,37.36 87.01,47.84 90,50.83 90,51.97 93.08,55.05 93.47,55.05 93.87,55.45 93.87,56.37 v2(94.13,56.63)
  BOTTOM w0.109: v1(166.13,24.19) 166.65,24.7 R64.1
AP_SPI_H1_TPM_CLK_R: length 5.8
  TOP w0.089: 98.1,56.67 98.48,57.05 99.71,57.05 99.89,56.87 100.6,56.87 U1JSL.CR38
  TOP w0.109: R390.1 v4(95.73,56.67) 98.1,56.67
AP_SPI_H1_TPM_CS_L: length 133.5
  TOP w0.079: U13.J8 167.67,22.6 168.83,23.75 v1(168.85,23.75)
  TOP w0.089: v2(98.01,57.15) 98.14,57.29 99.79,57.29 100.03,57.05 100.32,57.05 100.36,57.09 100.78,57.09 100.81,57.06 100.92,57 101.05,56.98 101.22,57.02 101.39,57 101.63,56.84 U1JSL.CM38
  TOP w0.109: R66.1 169.1,23.51 v1(168.85,23.75)
  IN4 w0.089: v1(168.85,23.75) 167.71,24.9 167.71,27.85 166.31,29.25 164.99,29.25 163.7,30.54 163.18,30.54 160.99,32.73 150.96,32.73 146.89,28.65 145.62,28.65 140.04,23.07 126.51,23.07 126.33,23.25 114.47,23.25 114.1,22.88 106.9,22.88 106,23.77 96.02,23.77 94.73,25.06 92.61,25.06 91.11,26.55 90.69,26.55 87.69,29.55 87.69,37.35 87.48,37.55 87.48,46.56 90.62,49.7 90.62,51.9 93.27,54.56 95.48,54.56 98.01,57.09 98.01,57.15 v2(98.01,57.15)
AP_SPI_H1_TPM_MISO: length 128.8
  TOP w0.089: v2(98.72,56.29) 98.72,56.34 99.05,56.67 99.49,56.67 99.64,56.52 100.32,56.52 100.51,56.32 100.9,56.32 U1JSL.CP39
  TOP w0.109: v2(168.17,25.84) 168.34,25.66 R395.1
  IN4 w0.089: v2(168.17,25.84) 168.55,26.22 168.55,27.49 166.45,29.59 165.13,29.59 163.84,30.88 163.32,30.88 161.13,33.07 150.82,33.07 146.74,28.99 145.47,28.99 140.33,23.85 121.76,23.85 121.57,23.66 106.6,23.66 106.15,24.12 96.16,24.12 94.88,25.4 92.76,25.4 91.24,26.91 90.81,26.91 88.03,29.7 88.03,37.49 87.83,37.69 87.83,46.37 90.08,48.62 91.53,49.21 93.87,49.21 94.13,49.46 96.16,49.46 97.17,50.48 97.17,52.77 96.73,53.21 96.73,54.27 98.72,56.26 v2(98.72,56.29)
AP_SPI_H1_TPM_MISO_R: length 2.4
  TOP w0.079: U13.H9 167,23.36 167.43,23.79 167.43,24.11 167.86,24.54
  TOP w0.109: R395.2 168.26,24.93 167.86,24.54
AP_SPI_H1_TPM_MOSI: length 125.3
  TOP w0.079: U13.C9 164.5,23.21 164.29,23.42 164.29,24.14 164.38,24.23 v1(164.38,24.26)
  TOP w0.117: v2(93.39,55.69) 93.41,55.69 93.92,56.2 96.29,56.2 R391.2
  IN4 w0.089: v1(164.38,24.26) 164.23,24.41 164.23,25.98 164.53,26.29 164.53,28.05 164.03,28.55 163.83,28.55 160.6,31.79 151.35,31.79 147.26,27.7 146.01,27.7 144.64,26.32 144.64,25.78 143.99,25.13 143.59,25.13 142.41,23.95 142.41,23.55 140.96,22.1 126.01,22.1 125.8,22.31 115.14,22.31 114.77,21.94 106.49,21.94 105.97,22.46 102.94,22.46 102.57,22.83 95.63,22.83 94.35,24.12 91.77,24.12 86.75,29.14 86.75,36.96 86.54,37.16 86.54,48.03 89.53,51.02 89.53,52.19 93.03,55.69 v2(93.39,55.69)
AP_SPI_H1_TPM_MOSI_R: length 6
  TOP w0.089: U1JSL.CL38 102.27,56.45 101.18,56.45 101.13,56.5 100.59,56.5 100.39,56.69 99.76,56.69 99.61,56.85 98.67,56.85 98.11,56.29
  TOP w0.109: R391.1 98.11,56.29
AP_SUB_IO_1: length 1.3
  TOP w0.089: v1(104.06,64.15) 104.16,64.15 104.48,63.83 U1JSL.CF23
  BOTTOM w0.114: TP108.1 104.58,64.15 v1(104.06,64.15)
AP_SUB_IO_2: length 3.2
  TOP w0.089: v2(103.44,74.12) 103.53,74.02 103.53,73.19 103.26,72.92 U1JSL.CJ3
  BOTTOM w0.114: v2(103.44,74.12) 104.23,74.92 TP109.1
AP_WP_OD: length 178.9
  TOP w0.089: 98.48,69.37 98.63,69.22 99.98,69.22 U1JSL.CT11
  TOP w0.109: Q4.3 166.9,28.91 166.9,28.61 166.35,28.07 166.35,27.37 166.25,27.27 v1(165.92,27.27) 165.71,27.47 R51.2 ; v2(97.22,69.86) 97.79,69.86 98.28,69.37 98.48,69.37
  IN2 w0.097: v2(93.23,16.61) 93.23,15.77 94.05,14.95 102.2,14.95 103.11,15.85 103.11,16.84 103.38,17.11 105.63,17.11 106.12,17.6 110.3,17.6 114.11,13.79 143.64,13.79 146.76,16.91 150.49,16.91 151.2,17.63 155.25,17.63 155.43,17.45 157.52,17.45 159.08,19.01 160.06,19.01 161.11,20.06 163.02,20.06 163.27,20.31 163.27,22.23 162.65,22.85 162.65,24.06 164.25,25.67 164.25,26.1 165.42,27.27 v1(165.92,27.27)
  IN4 w0.089: v2(93.23,16.61) 93.13,16.7 93.13,18.41 90.58,20.97 84.96,20.97 81.68,24.25 77.53,24.25 75.13,26.65 75.13,34.35 77.4,36.62 77.4,46.16 76.35,47.21 76.35,51.56 75.24,52.67 75.24,56.21 76.01,56.98 76.71,56.98 78.39,58.66 78.39,61.47 87.22,70.29 91.08,70.29 91.59,69.78 93.36,69.78 93.59,69.56 94.73,69.56 95.14,69.15 95.14,68.74 95.4,68.49 95.85,68.49 v2(97.22,69.86)
AUX_COMP: length 2.9
  TOP w0.109: U21.5 48.64,57.77 48.41,57.54 v4(48.41,57.01) 48.41,56.98 48.53,56.86 C323.1 48.16,56.34 48.08,56.42 C322.1
AUX_CS_DIS: length 1.3
  TOP w0.109: U21.1 48.4,59.37 48.15,59.62 R433.1
AUX_FB: length 5.4
  TOP w0.109: v4(48.53,55.23) 47.93,54.62 C332.1 R438.2 ; v4(48.53,55.23) C323.2 48.83,55.89 49.71,56.77 U21.6 ; v4(48.53,55.23) 49.05,54.71 R439.1
AUX_FS: length 2.1
  TOP w0.109: U21.9 50.91,55.79 R231.2 R431.1
AUX_LGATE:
  vias: v4(56.91,60.77)
AUX_SW: length 6.6
  TOP w0.203: 53.83,57.63 53.29,58.17 U21.12
  BOTTOM w0.381: C320.2 v2(55.53,56.82)
  BOTTOM w0.508: v2(64.79,53.66) 64.79,56.24 65.3,56.75 C333.1
  vias: v4(54.58,56.98)
BASE_SIXAXIS_INT_L: length 97.2
  TOP w0.079: U17.M2 158.08,21.09 158.13,21.14 158.27,21.14 158.79,21.66
  TOP w0.109: v1(159.1,21.81) 159.06,21.81 158.92,21.66 158.79,21.66
  IN1 w0.097: v1(159.1,21.81) 159.68,21.23 160.76,21.23 161.13,21.6 164.08,21.6 164.73,20.95 172.82,20.95 174.42,22.56 175.02,22.56 177.41,24.94 180.83,24.94 188.94,33.05 188.94,40.76 189.36,41.18 189.36,56.57 173.63,72.31 173.63,75.5 172.41,76.72 v2(170.67,76.72)
  BOTTOM w0.114: U15.4 171.1,71.83 v4(171.98,72.71) 171.98,75.11 170.67,76.42 v2(170.67,76.72)
BAT_DISABLE_OD: length 4.3
  BOTTOM w0.114: J14.6 94.6,18.95 94.63,18.98 Q14.3 92.46,19.84 R257.2
BAT_DISABLE_ODL: length 96.6
  TOP w0.079: U13.C8 164.74,22.83 164.74,22.99 164.74,22.99 164.74,23.27 164.53,23.48 164.53,23.86 v1(164.91,24.24)
  IN2 w0.097: v1(164.91,24.24) 164.53,23.86 164.53,22.59 164.12,22.18 164.12,19.35 163.08,18.32 159.29,18.32 157.75,16.78 154.96,16.78 154.75,16.98 151.45,16.98 147.53,13.05 113.92,13.05 109.97,17.01 107.64,17.01 v2(107.24,16.61)
  BOTTOM w0.114: v2(107.24,16.61) 107.24,17.31 106.67,17.88 106.67,19.29 104.76,21.21 102.15,21.21 98.22,25.13 90.06,25.13 89.78,24.86 89.78,21.59 v4(90.71,20.66) R91343.1
BATTERY_PRES_ODL: length 3.9
  BOTTOM w0.114: J14.5 96.6,19.3 96.79,19.49 R379.2 R256.2
BGATE: length 31.3
  TOP w0.203: v4(57.66,17.84) 57.71,17.84 57.74,17.87 U9.6
  IN2 w0.508: v3(85.49,17.56) 84.99,17.06 78.76,17.06 77.72,18.1 70.49,18.1 69.13,19.45 64.47,19.45 63.86,18.85 59.67,18.85 59,18.17 57.99,18.17 v4(57.66,17.84)
BL_PWM: length 59.5
  TOP w0.089: U1JSL.CC15 105.51,67.67 v1(105.51,67.68)
  IN1 w0.097: v2(90.01,67.52) 89.72,67.23 86.64,67.23 85.84,66.44 79.73,66.44 77.62,64.32 75.86,64.32 72.94,61.4 66.13,61.4 65.03,62.51 61.33,62.51 60.77,61.95 55.58,61.95 54.93,61.3 53.97,61.3 v2(53.18,60.51)
  BOTTOM w0.089: 101.01,67.79 102.22,67.79 102.7,67.3 105.13,67.3 v1(105.51,67.68)
  BOTTOM w0.114: J23.24 53.25,60.58 v2(53.18,60.51) ; 101.01,67.79 100.38,68.42 100.21,68.42 99.71,68.92 99.11,68.92 98.82,68.62 97.9,68.62 97.83,68.69 97.11,68.69 96.74,68.32 95.32,68.32 95.11,68.54 92.27,68.54 91.88,68.15 90.53,68.15 90.01,67.63 v2(90.01,67.52)
BT_DISABLE_L: length 124.4
  TOP w0.089: v1(104.78,65.01) 104.48,64.7 U1JSL.CF21
  TOP w0.109: v2(44.03,15.9) 43.37,15.9 43.15,16.12 R113.2
  IN1 w0.097: v2(89.35,19.58) 89.35,23.71 88.71,24.34 v2(88.71,24.84)
  IN2 w0.097: v2(44.03,15.9) 44.68,16.55 44.68,26.27 46.42,28.01 50.58,28.01 52.96,30.38 60.23,30.38 71.92,18.7 77.72,18.7 78.91,17.51 84.22,17.51 85.9,19.19 88.96,19.19 v2(89.35,19.58)
  IN4 w0.089: v1(104.78,65.01) 104.78,63.8 103.9,62.93 100.85,62.93 98.4,60.48 98.12,60.48 97.43,59.78 97.43,59.4 95.65,57.62 93.76,57.62 88.6,52.46 88.6,51.3 85.06,47.75 85.06,36.43 85.24,36.26 85.24,29.41 88.71,25.93 v2(88.71,24.84)
  BOTTOM w0.114: U4100.63 44.38,16.25 v2(44.03,15.9)
C2D2_CLK_UART_DBG_TX_EC_RX_SCL: length 15.7
  TOP w0.109: v2(172.97,29.88) 172.65,30.19 U1.7
  IN4 w0.089: v2(183.75,33.67) 183.19,33.11 182.2,33.11 179.52,30.43 175.56,30.43 175.13,30.86 173.17,30.86 172.97,30.66 v2(172.97,29.88)
  BOTTOM w0.114: v2(183.75,33.67) 184.31,33.11 J3.6
C2D2_CSN_UART_EC_TX_DBG_RX_SDA: length 19.9
  TOP w0.109: v2(172.95,26.3) 173.26,26.6 U1.1
  IN1 w0.097: v2(172.95,26.3) 172.95,27.66 174.08,28.79 179.3,28.79 179.74,29.22 v2(179.74,29.78)
  BOTTOM w0.114: J3.1 186.85,30.01 186.56,30.3 181.03,30.3 180.75,30.02 180.75,29.59 180.51,29.35 180.17,29.35 v2(179.74,29.78)
C2D2_HOLDN_ECVREF_H1_PWRBTN_ODL: length 16.4
  TOP w0.109: v2(173.47,30.19) 173.47,29.44 173.38,29.34 U1.6
  IN4 w0.089: v2(184.35,33.67) 183.48,32.8 182.24,32.8 179.65,30.21 175.48,30.21 175.05,30.64 173.91,30.64 173.47,30.21 v2(173.47,30.19)
  BOTTOM w0.114: J3.4 185.58,33.41 185.32,33.67 v2(184.35,33.67)
C2D2_MISO_UART_H1_TX_DBG_RX: length 21.6
  TOP w0.109: v2(173.21,25.18) 174.25,26.22 174.25,27.93 173.83,28.34 U1.4
  IN1 w0.097: v2(181.18,29.78) 180.94,29.78 179.52,28.36 174.3,28.36 173.69,27.75 173.69,25.66 v2(173.21,25.18)
  BOTTOM w0.114: J3.3 185.58,29.69 185.28,30 181.4,30 v2(181.18,29.78)
C2D2_MOSI_UART_DBG_TX_H1_RX: length 15.7
  TOP w0.109: U1.9 171.41,30.63 171.77,31 v2(171.77,31.08)
  IN4 w0.089: v2(183.14,33.65) 182.35,33.65 179.34,30.64 175.76,30.64 175.33,31.08 173.01,31.08 172.72,30.78 172.07,30.78 v2(171.77,31.08)
  BOTTOM w0.114: J3.8 183.04,33.55 v2(183.14,33.65)
C2D2_MUX_UART_ODL: length 26.6
  TOP w0.109: v2(169.69,31.08) 170.05,31.08 170.41,30.71 U1.11 ; U1.21 170.91,25.12 v2(170.91,25.12)
  IN2 w0.097: v2(184.41,26.55) 183.99,26.97 177.92,26.97 177.7,26.76 172.87,26.76 172.09,25.98 172.09,24.81 171.75,24.47 171.25,24.47 170.93,24.79 170.93,25.09 v2(170.91,25.12)
  BOTTOM w0.114: v2(170.91,25.12) 170.91,25.14 170.57,25.48 R155.2 170.27,25.77 169.93,26.11 169.93,26.33 169.37,26.88 169.37,29.44 169.69,29.75 v2(169.69,31.08) ; J3.5 184.31,26.66 v2(184.41,26.55)
C2D2_VREF_H1_RST_ODL: length 22
  TOP w0.109: v2(172.95,25.72) 173.2,25.72 173.98,26.5 173.98,27.76 173.9,27.84 U1.3
  IN1 w0.097: v2(180.32,29.78) 180.32,29.46 179.43,28.57 174.21,28.57 173.47,27.84 173.47,26.24 v2(172.95,25.72)
  BOTTOM w0.114: v2(180.32,29.78) 180.32,30.11 180.85,30.64 186.72,30.64 186.85,30.77 J3.2
CBI_EEPROM_WP: length 6.4
  TOP w0.109: v1(165.44,30.1) 165.44,29.66 v4(165.19,29.42) 164.89,29.12 R52.1 163.99,29.12 163.21,28.34 163.21,27.82 162.88,27.49 162.46,27.49 162.19,27.76 U12.7
  BOTTOM w0.114: v1(165.44,30.1) 165.57,30.23 U41.4
CCD_MODE_ODL: length 217.3
  TOP w0.079: v1(164.13,18.38) 164.13,18.91 164,19.04 U13.B1 ; v1(152.91,26.62) U17.F10
  TOP w0.109: v2(31.76,71.11) 31.9,70.96 Q12.2 31.9,70.11 31.72,69.94 29.72,69.94 29.54,70.11 Q13.2
  IN2 w0.097: v2(31.76,71.11) 36.75,71.11 v2(37.4,70.46)
  IN4 w0.079: 153.41,27.11 v1(152.91,26.62) 152.55,26.97 152.1,26.97 151.94,26.81 151.94,25.82 151.76,25.64 150.56,25.64 150.39,25.47
  IN4 w0.089: v1(164.13,18.38) 164.13,18.53 164.23,18.63 164.23,20.98 162.68,22.53 162.07,22.53 161.6,23 161.6,24.04 158.58,27.06 158.2,27.06 157.9,27.35 157.36,27.35 157.22,27.49 153.79,27.49 153.41,27.11 ; v2(82.92,48.44) 83.49,47.87 83.49,24.21 86.32,21.39 90.76,21.39 93.2,18.95 97.88,18.95 98.63,19.69 101.49,19.69 102.24,18.95 110.51,18.95 111.77,17.69 132.8,17.69 132.98,17.51 144.9,17.51 148.3,20.92 148.33,20.92 148.35,20.94 149.12,20.94 150.03,21.86 150.03,23.23 150.25,23.46 150.25,25.33 150.39,25.47
  BOTTOM w0.114: v2(82.92,48.44) 82.17,48.44 80.03,46.29 74.19,46.29 71.77,43.88 70,43.88 68.91,42.79 63.1,42.79 61.29,44.6 48.83,44.6 43.54,49.88 43.54,56.2 42.91,56.83 40.82,56.83 40.23,57.43 39.3,57.43 39.07,57.66 39.07,60.07 38.75,60.39 38.75,62.55 39.01,62.8 39.01,65.37 37.99,66.38 37.99,69.53 37.69,69.83 37.69,70.17 v2(37.4,70.46) ; v1(164.13,18.38) 164.6,17.91 R75.2 165.82,17.44 166.13,17.13 171.19,17.13 171.53,17.47 171.53,18.21 171.87,18.55 172.27,18.55 172.74,18.08 172.74,14.21 J2.1
CFG_RCOMP: length 3.6
  TOP w0.089: U1JSL.N1 128.84,73.44 128.84,74.76 130.1,76.03 R6F3.1
CHARGER_BATGONE: length 2.5
  TOP w0.203: U9.22 65.03,16.67 65.86,15.84 R1012.1
CHARGER_CMPIN: length 9.8
  TOP w0.203: v2(61.51,21.27) 61.51,21.04 61.41,20.94 U9.36
  BOTTOM w0.254: v2(61.51,21.27) 61.51,21.27 C1028.1 61.41,20.61 59.96,20.61 59.45,21.11 59.45,21.63 v4(59.01,22.07) 58.29,22.79 57.8,22.79 57.55,22.54 57.55,21.9 56.95,21.3 R1001.1 56.28,20.92 56.34,20.86 Q1009.1
CHARGER_CMPOUT_OD: length 1.7
  TOP w0.109: U9.30 64.01,20.71 v2(63.95,20.77)
  BOTTOM w0.114: R1013.1 64.19,20.77 v2(63.95,20.77)
CHARGER_COMPF: length 5
  TOP w0.109: U9.12 60.21,15.18 60.26,15.13 60.26,14.71 59.96,14.41 v2(59.96,14.34)
  BOTTOM w0.114: v2(59.96,14.34) 58.31,14.34 58.13,14.16 C1008.1 R1003.1
CHARGER_COMPR: length 6.4
  TOP w0.109: U9.13 60.61,14.98 v2(60.7,14.9)
  BOTTOM w0.114: v2(60.7,14.9) 60.7,14.4 60.21,13.92 59.35,13.92 R1005.1 C1010.1
CLK_24M_UCAM: length 9.9
  TOP w0.089: v1(102.8,70.46) 102.8,70.44 U1JSL.CJ9
  BOTTOM w0.109: v4(96.18,72.58) 96.31,72.7 R6D67.2 96.92,73.34 R6D66.2 97.02,73.06 97.55,72.53 98.52,72.53 98.61,72.61 99.22,72.61 99.44,72.38 99.44,72.31 99.99,71.77 99.99,71.41 100.35,71.05 100.85,71.05 101.4,70.5 102.01,70.5 102.22,70.7 102.56,70.7 v1(102.8,70.46)
CLK_24M_WCAM: length 8.1
  TOP w0.109: U1JSL.CK3 102.91,72.88 102.91,73.42 102.86,73.47 102.86,74.44 103.73,75.31 103.73,80.03 TP130.1
CLK_BIASREF: length 5.9
  TOP w0.109: U1JSL.BG3 113.41,72.5 113.41,72.95 113.6,73.14 113.6,73.44 112.67,74.37 112.67,75.28 111.85,76.09 v4(111.85,76.49) 112.23,76.87 R6E3.1
CNV_BRI_DT: length 112.8
  TOP w0.089: v2(97.71,72.93) R401.2
  TOP w0.109: v2(44.04,19.37) 44.5,19.82 44.5,25.47 v2(46.02,26.99)
  IN1 w0.097: v2(81.86,26.82) 81.42,26.38 76.02,26.38 75.04,27.35 71.99,27.35 71.62,26.99 64.47,26.99 63.56,27.9 62.86,27.9 60.06,30.7 54.32,30.7 51.97,28.35 47.14,28.35 46.02,27.24 v2(46.02,26.99)
  IN4 w0.089: v2(81.86,26.82) 81.86,26.84 81.24,27.46 81.24,33.68 78.62,36.29 78.62,46.68 78.14,47.17 78.14,56.62 80.26,58.75 80.26,61.59 87.34,68.67 89.15,68.67 89.25,68.57 91.64,68.57 91.86,68.34 94.25,68.34 94.91,67.68 96.4,67.68 98.01,69.28 98.01,70.79 97.71,71.09 v2(97.71,72.93)
  BOTTOM w0.109: U4100.A38 43.31,19.75 43.69,19.37 v2(44.04,19.37)
CNV_BRI_DT_R: length 4
  TOP w0.089: U1JSL.CP4 100.36,72.47 99.99,72.47
  TOP w0.109: R401.1 97.53,72.48 97.56,72.52 99.94,72.52 99.99,72.47
CNV_BRI_RSP: length 126.4
  TOP w0.089: U1JSL.CJ1 103.2,73.43 103.06,73.57 103.06,74.29 103.98,75.21 103.98,77.45 104.16,77.62
  TOP w0.109: v2(104.16,77.79) 104.16,77.62 ; v2(48.45,28.8) 47.65,28.01 46.19,28.01 42.39,24.21 R119.2
  IN1 w0.097: v2(48.45,28.8) 48.61,28.64 51.93,28.64 54.22,30.93 60.17,30.93 62.94,28.16 64.2,28.16 65.13,27.23 71.51,27.23 71.87,27.6 75.16,27.6 76.12,26.64 81.1,26.64 81.26,26.79 v2(81.26,26.82)
  IN4 w0.089: v2(104.16,77.79) 101.49,77.79 97.05,73.34 97.05,72.45 97.48,72.02 97.48,71 97.78,70.7 97.78,69.38 96.29,67.89 95.05,67.89 94.38,68.57 91.95,68.57 91.74,68.78 89.36,68.78 89.25,68.9 87.24,68.9 80.03,61.69 80.03,58.84 77.92,56.73 77.92,47.05 78.39,46.58 78.39,36.15 80.99,33.55 80.99,27.12 81.26,26.84 v2(81.26,26.82)
CNV_BRI_RSP_R: length 2
  TOP w0.109: R119.1 43.41,18.89 43.49,18.81 v2(43.82,18.81)
  BOTTOM w0.114: v2(43.82,18.81) 43.77,18.86 43.77,18.88 43.4,19.25 U4100.A39
CNV_CLK_PCH_RX_WLAN_TX_N: length 90.4
  TOP w0.089: U1JSL.CD41 v1(105.2,55.22)
  IN1 w0.089: v1(105.2,55.22) 105.32,55.1 106.01,55.1 106.3,54.82 106.3,53.8 106.57,53.53 106.57,52.77 105.3,51.5 104.87,51.5 103.72,50.34 101.23,50.34 100.7,49.82 100.45,49.82 100.44,49.81 100.42,49.81
  IN1 w0.097: v2(43.82,22.26) 43.91,22.36 43.92,22.36 44.01,22.45 44.53,22.45 45.04,22.96 45.04,27.13 49.8,31.89 60.51,31.89 63.24,29.16 64.65,29.16 65.72,28.08 70.73,28.08 74.86,32.21 74.86,33.27 75.56,33.97 81.96,33.97 85.03,37.04 85.03,43.2 88.95,47.12 93.64,47.12 93.86,47.33 93.86,47.42 93.96,47.52 94.37,47.52 94.46,47.42 94.46,47.33 94.68,47.12 96.14,47.12 98.83,49.81 100.42,49.81
  BOTTOM w0.097: U4100.A33 43.8,22.25 v2(43.82,22.26)
CNV_CLK_PCH_RX_WLAN_TX_P: length 90.4
  TOP w0.089: U1JSL.CD42 105.5,54.96 105.34,54.8 105.34,54.55 105.48,54.42 105.66,54.42 v2(105.73,54.49)
  IN1 w0.089: 100.42,50.01 100.44,50.01 100.45,50 100.63,50 101.15,50.52 103.65,50.52 104.8,51.67 105.23,51.67 106.39,52.84 106.39,53.46 106.12,53.73 106.12,54.74 105.94,54.93 105.68,54.93 105.57,54.81 105.57,54.66 v2(105.73,54.49)
  IN1 w0.097: v2(43.82,22.85) 44,22.66 44.45,22.66 44.83,23.04 44.83,27.21 49.71,32.09 60.6,32.09 63.33,29.36 64.73,29.36 65.81,28.28 70.65,28.28 74.66,32.29 74.66,33.35 75.48,34.17 81.87,34.17 84.82,37.12 84.82,43.28 88.86,47.32 93.56,47.32 93.66,47.42 93.66,47.51 93.87,47.72 94.45,47.72 94.67,47.51 94.67,47.42 94.76,47.32 96.06,47.32 98.75,50.01 100.42,50.01
  BOTTOM w0.097: v2(43.82,22.85) 43.72,22.75 U4100.A32
CNV_CLK_PCH_TX_WLAN_RX_N: length 124
  TOP w0.089: v2(107.56,53.97) U1JSL.BY44
  IN1 w0.089: 100.42,48.45 100.44,48.45 100.45,48.46 100.77,48.46 101.23,48.92 103.6,48.92 105.1,50.43 105.68,50.43 108.07,52.82 108.07,53.36 107.56,53.87 v2(107.56,53.97)
  IN1 w0.097: v2(34.29,19.82) 34.18,19.71 33.84,19.71 33.59,19.46 33.59,11.84 37.11,8.32 51.61,8.32 52.8,9.51 54.36,9.51 56.69,11.83 59.7,11.83 61.37,13.5 65.55,13.5 66.45,14.4 71.51,14.4 74.24,17.12 74.24,20.86 75.11,21.74 81.65,21.74 84.41,24.5 84.41,27.36 85.45,28.4 85.45,28.92 85.57,29.04 87.07,29.04 87.3,29.27 87.3,29.67 87.03,29.95 85.59,29.95 85.44,30.09 85.44,30.34 85.6,30.5 87.04,30.5 87.3,30.77 87.3,35.38 87.08,35.61 86.03,35.61 85.91,35.73 85.91,36.03 86.08,36.21 87.03,36.21 87.3,36.48 87.3,43.64 89.08,45.42 96.54,45.42 99.57,48.45 100.42,48.45
  BOTTOM w0.097: U4100.A20 34.72,20.25 v2(34.29,19.82)
CNV_CLK_PCH_TX_WLAN_RX_P: length 124
  TOP w0.089: U1JSL.BY45 106.83,53.63 106.76,53.57 106.76,53.43 107.07,53.12 107.38,53.12 v2(107.56,53.3)
  IN1 w0.089: v2(107.56,53.3) 107.62,53.36 107.82,53.36 107.89,53.29 107.89,52.89 105.61,50.61 105.03,50.61 103.52,49.1 101.16,49.1 100.69,48.64 100.45,48.64 100.44,48.65 100.42,48.65
  IN1 w0.097: v2(34.29,19.24) 34.02,19.51 33.92,19.51 33.79,19.38 33.79,11.93 37.2,8.52 51.53,8.52 52.71,9.71 54.28,9.71 56.61,12.04 59.62,12.04 61.28,13.7 65.47,13.7 66.37,14.6 71.43,14.6 74.03,17.21 74.03,20.95 75.03,21.94 81.56,21.94 84.2,24.58 84.2,27.45 85.25,28.49 85.25,29 85.48,29.24 86.98,29.24 87.1,29.36 87.1,29.58 86.94,29.74 85.5,29.74 85.24,30.01 85.24,30.42 85.52,30.71 86.95,30.71 87.1,30.85 87.1,35.3 86.99,35.41 85.95,35.41 85.7,35.65 85.7,36.12 86,36.41 86.94,36.41 87.1,36.57 87.1,43.72 88.99,45.62 96.45,45.62 99.48,48.65 100.42,48.65
  BOTTOM w0.097: U4100.A19 34.81,19.75 34.7,19.64 34.7,19.18 34.59,19.07 34.46,19.07 v2(34.29,19.24)
CNV_CLKREQ0: length 117.2
  TOP w0.089: U1JSL.CN23 101.19,63.15 101.01,63.15 100.82,63.21 99.76,63.21 99.33,62.77 99.02,62.77 v2(98.62,63.17)
  TOP w0.109: v2(46.02,25.8) 45.09,24.87 45.09,17.56 v2(44.03,16.5) 43.71,16.5 43.29,16.91 R422.1
  IN1 w0.097: v2(98.62,63.17) 97.85,63.94 96.96,63.94 95.16,65.75 95.16,66.34 94.41,67.09 v2(93.87,67.09) ; v2(80.89,25.63) 80.65,25.87 75.79,25.87 74.78,26.89 72.25,26.89 71.87,26.52 64.29,26.52 63.41,27.4 62.73,27.4 59.87,30.26 54.52,30.26 52.16,27.91 47.33,27.91 46.67,27.24 46.67,26.37 46.1,25.8 v2(46.02,25.8)
  IN4 w0.089: v2(80.89,25.63) 81.38,26.12 81.71,26.12 82.25,26.66 82.25,33.61 79.29,36.56 79.29,47.01 78.78,47.52 78.78,56.08 83.08,60.38 83.08,63.43 86.96,67.32 89.25,67.32 89.85,67.92 91.32,67.92 91.58,67.66 93.3,67.66 93.87,67.09 v2(93.87,67.09)
  BOTTOM w0.109: U4100.A43 43.27,17.25 44.02,16.5 v2(44.03,16.5)
CNV_D0_PCH_RX_WLAN_TX_N: length 90.3
  TOP w0.089: v2(105.71,53.2) 105.66,53.15 105.4,53.15 105.23,53.32 U1JSL.CE45
  IN1 w0.089: 100.42,50.74 100.43,50.75 100.45,50.75 100.65,50.95 103.28,50.95 105.33,53 105.51,53 v2(105.71,53.2)
  IN1 w0.097: 100.42,50.74 100.31,50.63 98.41,50.63 96.29,48.51 89.2,48.51 84.01,43.32 84.01,37.17 81.62,34.78 75.19,34.78 73.98,33.58 73.98,32.49 70.39,28.89 66.52,28.89 65.38,30.03 63.52,30.03 60.46,33.09 49.86,33.09 43.2,26.44 43.2,25.53 43.41,25.31 44.04,25.31 44.13,25.22 44.13,25.02 44.04,24.92 43.41,24.92 43.2,24.7 43.2,22.01 43.41,21.79 43.41,21.27 43.58,21.09 v2(43.82,21.09)
  BOTTOM w0.097: U4100.A35 43.17,21.25 43.34,21.42 43.49,21.42 v2(43.82,21.09)
CNV_D0_PCH_RX_WLAN_TX_P: length 90.3
  TOP w0.089: U1JSL.CE44 105.47,53.83 v2(105.73,53.83)
  IN1 w0.089: 100.56,50.59 100.58,50.61 100.58,50.63 100.73,50.78 103.36,50.78 105.4,52.82 105.88,52.82 106.11,53.04 106.11,53.33 105.73,53.7 v2(105.73,53.83)
  IN1 w0.097: 100.56,50.59 100.4,50.43 98.5,50.43 96.37,48.31 89.28,48.31 84.21,43.24 84.21,37.09 81.7,34.58 75.27,34.58 74.19,33.5 74.19,32.4 70.47,28.69 66.44,28.69 65.3,29.83 63.43,29.83 60.37,32.89 49.94,32.89 43.4,26.35 43.4,25.61 43.5,25.52 44.12,25.52 44.34,25.3 44.34,24.93 44.12,24.72 43.5,24.72 43.4,24.62 43.4,22.09 43.81,21.68 v2(43.82,21.68)
  BOTTOM w0.097: v2(43.82,21.68) 43.74,21.6 43.36,21.6 43.21,21.75 U4100.A34
CNV_D0_PCH_TX_WLAN_RX_N: length 123.6
  TOP w0.089: v2(106.66,54.63) 106.66,54.77 106.42,55.01 106.27,55.01 U1JSL.CC42
  IN1 w0.089: 100.42,49.31 100.44,49.31 100.45,49.3 100.71,49.3 101.01,49.6 103.39,49.6 104.95,51.17 105.4,51.17 107.02,52.79 107.02,54.84 106.94,54.93 106.77,54.93 106.66,54.81 v2(106.66,54.63)
  IN1 w0.097: v2(34.29,20.99) 34.68,20.6 34.68,20.31 35.27,19.72 35.27,11.55 37.68,9.14 51.28,9.14 52.47,10.33 53.98,10.33 57.59,13.94 60.11,13.94 60.49,14.31 64.62,14.31 65.56,15.25 69.31,15.25 73.41,19.35 73.41,21.25 74.89,22.73 81.46,22.73 83.59,24.86 83.59,30.01 85.35,31.77 85.89,31.77 86.18,31.48 86.35,31.48 86.49,31.61 86.49,32.03 86.09,32.43 86.09,32.8 86.49,33.2 86.49,33.42 86.09,33.82 86.09,34.13 86.49,34.53 86.49,34.68 86.37,34.8 84.46,34.8 84.21,35.05 84.21,35.48 84.56,35.84 84.95,35.84 85.02,35.91 85.02,36.34 85.77,37.1 86.38,37.1 86.49,37.2 86.49,37.65 86.09,38.06 86.09,38.7 86.49,39.1 86.49,39.45 86.38,39.56 86.04,39.56 85.78,39.81 85.78,40.27 86.02,40.51 86.38,40.51 86.49,40.62 86.49,40.77 86.17,41.09 86.17,41.48 86.49,41.79 86.49,42.01 86.37,42.12 86,42.12 85.78,42.34 85.78,42.8 86.07,43.09 86.38,43.09 86.49,43.2 86.49,43.98 89.14,46.64 96.35,46.64 99.03,49.31 100.42,49.31
  BOTTOM w0.097: v2(34.29,20.99) 34.55,21.25 U4100.A22
