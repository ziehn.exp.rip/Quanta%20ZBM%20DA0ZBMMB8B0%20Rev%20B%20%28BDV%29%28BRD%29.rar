# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
WSON8-6X5-1_27-9P-W25Q64FWZPIG
  rect 0.508x1.499 smd: 1(-1.905,-2.85) 2(-0.635,-2.85) 3(0.635,-2.85) 4(1.905,-2.85) 5(1.905,2.85) 6(0.635,2.85) 7(-0.635,2.85) 8(-1.905,2.85)
  rect 4.293x3.404 smd: 9(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
XTL-2X1_6-1_4X1_1-4P
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)

## Nets
0V6_DRAM_EN: R295.1 U22.7
0V6_DRAM_SNS: R443.2 R444.1 U22.2(VTTSNS)
1V1_DRAM_EN: R239.1 U22.8
1V1_DRAM_FB: C380.2 R445.2 R446.1 U22.6
1V1_DRAM_LGATE: Q34.8 U22.15
1V1_DRAM_SW: C366.2 L14.1 Q34.9 U22.16
1V1_DRAM_UGATE: Q34.1 U22.17
1V8_FB: C268.2 R277.2 R278.1 U32.5
1V8_SW: C266.2 L17.1 U32.8 U32.9 U32.10
1V8_VCC: C267.1 U32.6
3V3_IN: C251.1 C253.1 C357.1 R258.2 U30.5
3V3_LDO3: C358.1 R91318.1 U30.11
3V3_SW: C255.2 L15.1 U30.2
3V3_VCC: C248.1 U30.9
5V_IN: C250.1 C400.1 R259.2 U31.5
5V_LDO5: C354.1 U31.12
5V_SW: C254.2 L16.1 U31.2
5V_VCC: C256.1 U31.11
AGND_HP: C68.2 C69.2 C70.2 C72.2 C73.2 C75.1 C76.2 C77.2 C79.2 C81.1 J16.5 J16.7 R87.2 R184.2 R185.2 R91339.2 U3.11 U3.19
GND: C1.2 C1A6.2 C2.2 C3.2 C3C8.2 C3C9.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.1 C13.2 C14.2 C15.2 C16.1 C17.2 C18.1 C19.1 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C71.2 C74.1 C78.2 C80.2 C89.2 C90.2 C92.2 C96.2 C98.2 C102.1 C103.2 C104.2 C105.1 C106.1 C107.2 C108.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.1 C125.2 C126.2 C127.2 C128.2 C129.2 C130.1 C131.2 C132.1 C133.2 C134.2 C135.1 C136.1 C139.2 C140.1 C141.2 C142.2 C143.1 C144.1 C148.2 C155.1 C158.2 C159.2 C160.2 C163.2 C164.1 C165.2 C166.2 C167.2 C174.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C190.1 C191.2 C192.2 C193.2 C194.2 C195.1 C196.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C226.2 C227.2 C230.2 C231.2 C232.1 C233.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C256.2 C259.2 C260.2 C261.2 C262.2 C263.2 C265.2 C267.2 C269.2 C270.2 C271.2 C272.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C286.2 C287.2 C288.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C306.2 C307.2 C308.2 C309.2 C310.2 C313.2 C314.1 C315.2 C316.2 C317.2 C318.2 C319.2 C321.2 C325.1 C326.2 C327.1 C328.2 C329.2 C330.1 C331.2 C334.1 C335.1 C336.2 C337.2 C338.1 C339.2 C340.1 C341.2 C342.1 C343.2 C344.1 C345.2 C346.1 C347.1 C348.1 C349.1 C350.2 C351.2 C352.1 C353.2 C354.2 C355.1 C356.2 C357.2 C358.2 C359.1 C360.2 C361.2 C362.2 C363.2 C365.2 C367.2 C368.2 C369.2 C370.2 C371.2 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C381.2 C382.2 C386.2 C387.2 C388.2 C389.2 C390.2 C391.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.1 C406.1 C407.2 C412.2 C413.2 C414.1 C416.2 C418.2 C419.2 C422.2 C424.1 C426.2 C474.2 C486.1 C487.2 C488.2 C489.2 C491.2 C502.2 C503.2 C504.2 C583.2 C587.2 C1000.2 C1001.2 C1002.2 C1003.2 C1004.2 C1005.2 C1006.2 C1007.2 C1008.2 C1009.2 C1010.2 C1011.2 C1012.2 C1013.2 C1014.2 C1015.2 C1016.2 C1017.2 C1018.2 C1025.2 C1027.2 C1028.2 C1035.2 C1036.2 C1045.1 C3205.2 C3208.2 C3210.2 C3213.2 C3216.2 C3406.1 C3423.2 C3501.2 C3504.2 C3508.2 C3512.2 C3514.2 C3517.2 C3522.1 C3526.1 C3530.1 C3531.1 C3535.2 C3562.2 C3563.2 C3564.2 C3609.2 C4101.2 C4102.2 C4103.2 C4104.2 C4301.2 C4401.2 C4501.2 C4502.2 C4503.2 C4504.2 C4505.2 C4506.2 C4507.2 C4508.2 C4509.2 C4510.2 C4511.2 C4512.2 C4513.2 C4514.2 C4515.2 C4516.2 C4517.2 C4518.2 C4519.2 C4520.2 C4521.2 C4522.2 C4523.2 C4524.2 C4525.2 C4526.2 C4527.2 C4528.2 C4529.2 C4530.2 C4531.2 C4532.2 C4533.2 C4534.2 C4535.2 C4536.2 C4537.2 C4538.2 C4539.2 C4540.2 C4541.2 C4601.2 C4701.2 C4801.2 C4802.2 C4803.2 C4804.2 C4805.2 C4806.2 C4807.2 C4808.2 C4809.2 C4810.2 C4811.2 C4812.2 C4813.2 C4814.2 C4815.2 C4816.2 C4817.2 C4818.2 C4819.2 C4820.2 C4821.2 C4822.2 C4823.2 C4824.2 C4825.2 C4826.2 C4827.2 C4828.2 C4829.2 C4830.2 C4831.2 C4832.2 C4833.2 C4834.2 C4835.2 C4836.2 C4837.2 C4838.2 C4839.2 C4840.2 C4841.2 C10711.2 C27101.1 C27102.1 C27104.2 C27218.2 C27220.2 C27222.2 C27224.2 C27226.2 C27228.2 C27230.2 C28002.1 C28004.2 C28005.2 C28006.2 C28007.2 C28008.1 C28009.2 C28010.2 C28011.2 C28015.1 C28016.1 C28017.2 C28018.2 C28019.2 C28020.2 C28021.1 C28024.2 C28025.2 C28026.2 CN2.5 CN2.6 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR6.2 CR7.2 D1.5(GND) D2.5(GND) D3.5(GND) D4.5(GND) D5.3 D5.8 D7.3 D7.8 D8.3 D8.8 D11.2 D12.2 D13.2 D14.2 D15.2 D16.5(GND) D17.5(GND) D25.2 D2741.3 D2742.3 D2743.2 D2744.2 D2745.2 D2746.2 D2748.2 HOLE17.1 HOLE18.1 HOLE19.1 HOLE20.1 HOLE23.1 HOLE25.1 HOLE26.1 HOLE27.1 HOLE28.1 HOLE29.1 HOLE32.1 HOLE34.1 HOLE35.1 HOLE36.1 HOLE38.1 HOLE39.1 HOLE40.1 HOLE41.1 HOLE42.1 HOLE43.1 HOLE44.1 HOLE45.1 HOLE46.1 J2.2 J3.7 J4.5 J4.6 J9.6(VSS) J9.10 J9.11 J9.12 J9.13 J9.14 J10.4 J10.7 J10.10 J10.11 J10.12 J10.13 J11.1 J11.2 J11.3 J11.4 J11.5 J11.6 J11.A1 J11.A12 J11.B1 J11.B12 J12.1 J12.12 J12.15 J12.21 J12.22 J13.1 J13.4 J13.7 J13.10 J13.13 J13.16 J13.19 J13.22 J13.25 J13.28 J13.31 J13.38 J13.51 J13.52 J14.1 J14.2 J14.9 J14.10 J15.14 J15.16 J15.57 J15.58 J15.60 J15.61 J15.62 J15.63 J15.64 J17.31 J17.32 J18.3 J18.7 J18.8 J23.2 J23.5 J23.9 J23.12 J23.15 J23.18 J23.21 J23.25 J23.40 J23.41 J23.42 J24.6 J24.7 J24.8 J25.31 J25.32 Q3.1 Q3.2 Q3.3(S_3) Q4.1(S) Q5.1(S) Q14.1(S) Q16.3 Q17.1(S) Q19.1(S) Q20.1(S) Q21.1(S) Q24.1(S) Q25.1(S) Q26.1(S) Q27.1(S) Q31.1 Q31.2 Q31.3(S_3) Q33.1 Q33.2 Q33.3(S_3) Q34.5 Q34.6 Q34.7(S2#3) Q35.5 Q35.6 Q35.7(S2#3) Q36.1(S) Q37.1(S) Q38.1(S) Q1001.5 Q1001.6 Q1001.7(S2#3) Q1002.1(S) Q1008.5 Q1008.6 Q1008.7(S2#3) Q1010.1(S) R1G1.2 R2C20.2 R4F20.2 R5F9.2 R5G69.2 R5M19.2 R6D29.2 R6D38.2 R6D82.2 R6E3.2 R6E5.2 R6F1.2 R6F3.2 R7D9.2 R7D24.2 R9.2 R22.2 R23.2 R40.2 R46.2 R49.2 R60.2 R61.2 R64.2 R66.2 R69.2 R72.2 R87.1 R107.2 R109.2 R120.2 R138.2 R146.2 R147.2 R154.2 R174.2 R176.2 R183.2 R191.2 R200.2 R211.2 R220.2 R221.2 R222.2 R223.2 R227.2 R231.1 R232.2 R236.2 R242.2 R254.2 R265.2 R278.2 R279.2 R283.2 R285.2 R287.2 R288.2 R294.2 R297.2 R298.2 R302.2 R305.2 R311.2 R319.1 R321.2 R323.2 R340.2 R341.2 R355.2 R368.2 R370.2 R371.2 R372.2 R373.2 R375.2 R378.2 R384.2 R387.1 R394.2 R402.2 R406.2 R414.2 R416.2 R418.2 R420.2 R422.2 R433.2 R437.1 R442.2 R444.2 R446.2 R449.2 R451.2 R458.2 R461.2 R474.2 R595.2 R596.2 R1001.2 R1009.2 R1012.2 R1022.2 R1023.2 R1024.2 R3803.2 R3808.2 R3809.2 R3810.2 R3812.2 R11103.2 R11107.2 R11108.2 R11109.2 R11110.2 R11111.2 R11112.2 R11114.2 R11120.2 R27121.2 R27288.2 R27289.2 R27292.2 R27305.2 R27306.2 R91321.2 R91322.2 R91326.2 R91339.1 R91347.1 R91348.1 R91351.2 R91352.2 R91353.2 R91358.1 R91359.1 R91360.1 R91362.1 RT756.2 RT854.2 SW1.2 SW1.4 SW1.5 SW1.6 SW1.7 U1.2 U1.17 U1.25 U1JSL.A4 U1JSL.A5 U1JSL.A10 U1JSL.A16 U1JSL.A21 U1JSL.A23 U1JSL.A27 U1JSL.A29 U1JSL.A32 U1JSL.A34 U1JSL.A37 U1JSL.A40 U1JSL.A43 U1JSL.A48 U1JSL.A49 U1JSL.AA47 U1JSL.AA50 U1JSL.AA52 U1JSL.AB1 U1JSL.AB6 U1JSL.AB10 U1JSL.AB15 U1JSL.AB17 U1JSL.AB18 U1JSL.AB20 U1JSL.AB21 U1JSL.AB23 U1JSL.AB25 U1JSL.AB33 U1JSL.AB38 U1JSL.AC20 U1JSL.AC21 U1JSL.AC23 U1JSL.AC25 U1JSL.AC33 U1JSL.AC47 U1JSL.AD6 U1JSL.AD10 U1JSL.AD15 U1JSL.AD38 U1JSL.AD52 U1JSL.AE17 U1JSL.AE18 U1JSL.AE33 U1JSL.AF1 U1JSL.AF39 U1JSL.AF41 U1JSL.AF42 U1JSL.AF44 U1JSL.AF45 U1JSL.AF47 U1JSL.AF50 U1JSL.AF52 U1JSL.AG9 U1JSL.AG13 U1JSL.AG15 U1JSL.AG17 U1JSL.AG18 U1JSL.AG33 U1JSL.AG34 U1JSL.AH17 U1JSL.AH18 U1JSL.AH33 U1JSL.AH38 U1JSL.AH47 U1JSL.AJ6 U1JSL.AJ10 U1JSL.AJ13 U1JSL.AJ52 U1JSL.AK1 U1JSL.AK18 U1JSL.AK38 U1JSL.AL47 U1JSL.AL50 U1JSL.AL52 U1JSL.AM6 U1JSL.AM13 U1JSL.AM18 U1JSL.AM33 U1JSL.AM39 U1JSL.AM41 U1JSL.AM42 U1JSL.AM44 U1JSL.AM45 U1JSL.AN1 U1JSL.AP18 U1JSL.AP38 U1JSL.AP47 U1JSL.AP52 U1JSL.AR9 U1JSL.AR13 U1JSL.AR18 U1JSL.AR33 U1JSL.AT38 U1JSL.AU1 U1JSL.AU3 U1JSL.AU6 U1JSL.AU10 U1JSL.AU18 U1JSL.AU47 U1JSL.AU50 U1JSL.AU52 U1JSL.AV39 U1JSL.AV41 U1JSL.AV42 U1JSL.AV44 U1JSL.AV45 U1JSL.AW9 U1JSL.AW13 U1JSL.AW33 U1JSL.AW47 U1JSL.AY23 U1JSL.AY33 U1JSL.AY38 U1JSL.AY39 U1JSL.AY52 U1JSL.B4 U1JSL.B5 U1JSL.B12 U1JSL.BA6 U1JSL.BA10 U1JSL.BA15 U1JSL.BB17 U1JSL.BB18 U1JSL.BB20 U1JSL.BB21 U1JSL.BB23 U1JSL.BB33 U1JSL.BB38 U1JSL.BB39 U1JSL.BB47 U1JSL.BB50 U1JSL.BB52 U1JSL.BC1 U1JSL.BC9 U1JSL.BD2 U1JSL.BD4 U1JSL.BD21 U1JSL.BD23 U1JSL.BD39 U1JSL.BD41 U1JSL.BD42 U1JSL.BD44 U1JSL.BD45 U1JSL.BE21 U1JSL.BE23 U1JSL.BE47 U1JSL.BE52 U1JSL.BF2 U1JSL.BF4 U1JSL.BF9 U1JSL.BF13 U1JSL.BF15 U1JSL.BF38 U1JSL.BG21 U1JSL.BG23 U1JSL.BG47 U1JSL.BG50 U1JSL.BG52 U1JSL.BH38 U1JSL.BJ1 U1JSL.BJ3 U1JSL.BJ9 U1JSL.BJ21 U1JSL.BJ23 U1JSL.BJ33 U1JSL.BK21 U1JSL.BK23 U1JSL.BK39 U1JSL.BK41 U1JSL.BK42 U1JSL.BK44 U1JSL.BK45 U1JSL.BK47 U1JSL.BK52 U1JSL.BL6 U1JSL.BL10 U1JSL.BL15 U1JSL.BM1 U1JSL.BM3 U1JSL.BM17 U1JSL.BM18 U1JSL.BM20 U1JSL.BM21 U1JSL.BM23 U1JSL.BM33 U1JSL.BM38 U1JSL.BN47 U1JSL.BN50 U1JSL.BN52 U1JSL.BP9 U1JSL.BP17 U1JSL.BP21 U1JSL.BP23 U1JSL.BP33 U1JSL.BP38 U1JSL.BP48 U1JSL.BR47 U1JSL.BT1 U1JSL.BT3 U1JSL.BT17 U1JSL.BT21 U1JSL.BT23 U1JSL.BT25 U1JSL.BT26 U1JSL.BT28 U1JSL.BT30 U1JSL.BT31 U1JSL.BT33 U1JSL.BT39 U1JSL.BT41 U1JSL.BT42 U1JSL.BT44 U1JSL.BT45 U1JSL.BT52 U1JSL.BU6 U1JSL.BU10 U1JSL.BU17 U1JSL.BU21 U1JSL.BU23 U1JSL.BU25 U1JSL.BU26 U1JSL.BU28 U1JSL.BU30 U1JSL.BU31 U1JSL.BU33 U1JSL.BU34 U1JSL.BV47 U1JSL.BV50 U1JSL.BV52 U1JSL.BW2 U1JSL.BW4 U1JSL.BW9 U1JSL.BW13 U1JSL.BW17 U1JSL.BW21 U1JSL.BY42 U1JSL.C13 U1JSL.C16 U1JSL.C21 U1JSL.C23 U1JSL.C29 U1JSL.C34 U1JSL.C40 U1JSL.C50 U1JSL.CA9 U1JSL.CA17 U1JSL.CA21 U1JSL.CA47 U1JSL.CA52 U1JSL.CB1 U1JSL.CB3 U1JSL.CB26 U1JSL.CB32 U1JSL.CB34 U1JSL.CB36 U1JSL.CC32 U1JSL.CC39 U1JSL.CC44 U1JSL.CC45 U1JSL.CC47 U1JSL.CC50 U1JSL.CC52 U1JSL.CD6 U1JSL.CD7 U1JSL.CD38 U1JSL.CE9 U1JSL.CE21 U1JSL.CE24 U1JSL.CE30 U1JSL.CE47 U1JSL.CF13 U1JSL.CF17 U1JSL.CF36 U1JSL.CF42 U1JSL.CF52 U1JSL.CG1 U1JSL.CH43 U1JSL.CJ4 U1JSL.CJ7 U1JSL.CJ15 U1JSL.CJ21 U1JSL.CJ23 U1JSL.CJ28 U1JSL.CJ32 U1JSL.CJ34 U1JSL.CJ38 U1JSL.CJ52 U1JSL.CK43 U1JSL.CL15 U1JSL.CL18 U1JSL.CL21 U1JSL.CL24 U1JSL.CL26 U1JSL.CL29 U1JSL.CL32 U1JSL.CL34 U1JSL.CL37 U1JSL.CL40 U1JSL.CL47 U1JSL.CM1 U1JSL.CM10 U1JSL.CM52 U1JSL.CN6 U1JSL.CN47 U1JSL.CP12 U1JSL.CP15 U1JSL.CP21 U1JSL.CP26 U1JSL.CP32 U1JSL.CP37 U1JSL.CR1 U1JSL.CR50 U1JSL.CT4 U1JSL.CT5 U1JSL.CT8 U1JSL.CT15 U1JSL.CT18 U1JSL.CT21 U1JSL.CT23 U1JSL.CT26 U1JSL.CT28 U1JSL.CT32 U1JSL.CT34 U1JSL.CT37 U1JSL.CT39 U1JSL.CT42 U1JSL.CT45 U1JSL.CT48 U1JSL.CT51 U1JSL.D1 U1JSL.D6 U1JSL.D16 U1JSL.D21 U1JSL.D41 U1JSL.D52 U1JSL.E7 U1JSL.E52 U1JSL.F4 U1JSL.F12 U1JSL.F13 U1JSL.F23 U1JSL.F26 U1JSL.F29 U1JSL.F31 U1JSL.F34 U1JSL.F37 U1JSL.F40 U1JSL.F43 U1JSL.F47 U1JSL.G5 U1JSL.G10 U1JSL.H1 U1JSL.H8 U1JSL.H10 U1JSL.H16 U1JSL.H20 U1JSL.H26 U1JSL.H32 U1JSL.H38 U1JSL.H39 U1JSL.H41 U1JSL.H42 U1JSL.H44 U1JSL.H45 U1JSL.H46 U1JSL.J10 U1JSL.J26 U1JSL.J32 U1JSL.J47 U1JSL.J52 U1JSL.K5 U1JSL.K38 U1JSL.K47 U1JSL.L6 U1JSL.L7 U1JSL.L8 U1JSL.L10 U1JSL.L16 U1JSL.L20 U1JSL.L26 U1JSL.L32 U1JSL.M26 U1JSL.M32 U1JSL.M38 U1JSL.M47 U1JSL.M52 U1JSL.N3 U1JSL.N11 U1JSL.P1 U1JSL.P16 U1JSL.P20 U1JSL.P26 U1JSL.P32 U1JSL.P39 U1JSL.P41 U1JSL.P42 U1JSL.P44 U1JSL.P45 U1JSL.R9 U1JSL.R13 U1JSL.R26 U1JSL.R28 U1JSL.R30 U1JSL.R32 U1JSL.R34 U1JSL.R36 U1JSL.R47 U1JSL.R50 U1JSL.R52 U1JSL.T38 U1JSL.U6 U1JSL.U12 U1JSL.U13 U1JSL.U20 U1JSL.U21 U1JSL.U23 U1JSL.U25 U1JSL.U26 U1JSL.V1 U1JSL.V3 U1JSL.V17 U1JSL.V18 U1JSL.V20 U1JSL.V21 U1JSL.V26 U1JSL.V28 U1JSL.V30 U1JSL.V33 U1JSL.V38 U1JSL.V47 U1JSL.V52 U1JSL.W9 U1JSL.W10 U1JSL.W13 U1JSL.Y17 U1JSL.Y18 U1JSL.Y20 U1JSL.Y21 U1JSL.Y23 U1JSL.Y25 U1JSL.Y33 U1JSL.Y39 U1JSL.Y41 U1JSL.Y42 U1JSL.Y44 U1JSL.Y45 U2.4 U2.15 U2.16 U2.17 U2.25 U2.26 U2.29 U2.30 U2.33 U3.41 U4.4 U4.15 U4.16 U4.17 U4.25 U4.26 U4.29 U4.30 U4.33 U5.B3 U6.14 U6.15 U6.18 U6.35 U6.37 U6.41 U7.9 U7.10 U7.11 U8.8 U8.13 U8.16 U8.17 U8.18 U8.21 U9.41 U10.33 U11.4 U11.9 U12.1 U12.2 U12.3 U12.4 U12.9 U13.C2 U13.D4 U13.D5 U13.D6 U13.E4 U13.E5 U13.E6 U13.F4 U13.F5 U13.F6 U13.G2 U14.A6 U14.C4 U14.E7 U14.G5 U14.H10 U14.J5 U14.K8 U14.N2 U14.N5 U14.P4 U14.P6 U15.1 U15.6 U15.7 U16.1 U16.2 U17.A1 U17.A5 U17.A8 U17.E1 U17.E12 U17.G1 U17.J12 U17.M3 U17.M4 U17.M9(VSS8) U21.14 U21.21 U22.1 U22.3 U22.11 U22.14 U22.21 U23.11 U23.15 U24.D1 U26.D1 U27.D1 U30.4 U30.8 U31.4 U31.8 U32.11 U33.9 U33.12 U33.17 U34.5 U34.7 U35.2 U36.2 U37.14 U37.17 U38.15 U40.B1 U41.3 U42.3 U4100.6 U4100.17 U4100.20 U4100.23 U4100.26 U4100.32 U4100.35 U4100.38 U4100.41 U4100.62 U4100.68 U4100.71 U4100.74 U4100.75 U4100.76 U4100.77 U4100.78 U4100.79 U4100.80 U4100.81 U4100.82 U4100.83 U4100.84 U4100.85 U4100.86 U4100.87 U4100.88 U4100.89 U4100.90 U4100.91 U4100.92 U4100.93 U4100.94 U4100.95 U4100.96 U4100.97 U4100.98 U4100.99 U4100.100 U4100.101 U4100.102 U4100.103 U4100.104 U4100.105 U4100.106 U4100.107 U4100.108 U4100.A7 U4100.A15 U4100.A26 U4100.A31 U4100.A50 U4301.A3 U4301.A10 U4301.AB3 U4301.AB5 U4301.AB8 U4301.AB10(VSS57) U4301.C1 U4301.C3 U4301.C5 U4301.C8 U4301.C10 U4301.C12 U4301.D2 U4301.D4 U4301.D9 U4301.D11 U4301.E1 U4301.E5 U4301.E8 U4301.E12 U4301.G1 U4301.G3 U4301.G5 U4301.G8 U4301.G10 U4301.G12 U4301.J1 U4301.J3 U4301.J10 U4301.J12 U4301.K2 U4301.K4 U4301.K9 U4301.K11 U4301.N2 U4301.N4 U4301.N9 U4301.N11 U4301.P1 U4301.P3 U4301.P10 U4301.P12 U4301.T1 U4301.T3 U4301.T5 U4301.T8 U4301.T10 U4301.T12 U4301.V1 U4301.V5 U4301.V8 U4301.V12 U4301.W2 U4301.W4 U4301.W9 U4301.W11 U4301.Y1 U4301.Y3 U4301.Y5 U4301.Y8 U4301.Y10 U4301.Y12 U4401.A3 U4401.A10 U4401.AB3 U4401.AB5 U4401.AB8 U4401.AB10(VSS57) U4401.C1 U4401.C3 U4401.C5 U4401.C8 U4401.C10 U4401.C12 U4401.D2 U4401.D4 U4401.D9 U4401.D11 U4401.E1 U4401.E5 U4401.E8 U4401.E12 U4401.G1 U4401.G3 U4401.G5 U4401.G8 U4401.G10 U4401.G12 U4401.J1 U4401.J3 U4401.J10 U4401.J12 U4401.K2 U4401.K4 U4401.K9 U4401.K11 U4401.N2 U4401.N4 U4401.N9 U4401.N11 U4401.P1 U4401.P3 U4401.P10 U4401.P12 U4401.T1 U4401.T3 U4401.T5 U4401.T8 U4401.T10 U4401.T12 U4401.V1 U4401.V5 U4401.V8 U4401.V12 U4401.W2 U4401.W4 U4401.W9 U4401.W11 U4401.Y1 U4401.Y3 U4401.Y5 U4401.Y8 U4401.Y10 U4401.Y12 U4601.A3 U4601.A10 U4601.AB3 U4601.AB5 U4601.AB8 U4601.AB10(VSS57) U4601.C1 U4601.C3 U4601.C5 U4601.C8 U4601.C10 U4601.C12 U4601.D2 U4601.D4 U4601.D9 U4601.D11 U4601.E1 U4601.E5 U4601.E8 U4601.E12 U4601.G1 U4601.G3 U4601.G5 U4601.G8 U4601.G10 U4601.G12 U4601.J1 U4601.J3 U4601.J10 U4601.J12 U4601.K2 U4601.K4 U4601.K9 U4601.K11 U4601.N2 U4601.N4 U4601.N9 U4601.N11 U4601.P1 U4601.P3 U4601.P10 U4601.P12 U4601.T1 U4601.T3 U4601.T5 U4601.T8 U4601.T10 U4601.T12 U4601.V1 U4601.V5 U4601.V8 U4601.V12 U4601.W2 U4601.W4 U4601.W9 U4601.W11 U4601.Y1 U4601.Y3 U4601.Y5 U4601.Y8 U4601.Y10 U4601.Y12 U4701.A3 U4701.A10 U4701.AB3 U4701.AB5 U4701.AB8 U4701.AB10(VSS57) U4701.C1 U4701.C3 U4701.C5 U4701.C8 U4701.C10 U4701.C12 U4701.D2 U4701.D4 U4701.D9 U4701.D11 U4701.E1 U4701.E5 U4701.E8 U4701.E12 U4701.G1 U4701.G3 U4701.G5 U4701.G8 U4701.G10 U4701.G12 U4701.J1 U4701.J3 U4701.J10 U4701.J12 U4701.K2 U4701.K4 U4701.K9 U4701.K11 U4701.N2 U4701.N4 U4701.N9 U4701.N11 U4701.P1 U4701.P3 U4701.P10 U4701.P12 U4701.T1 U4701.T3 U4701.T5 U4701.T8 U4701.T10 U4701.T12 U4701.V1 U4701.V5 U4701.V8 U4701.V12 U4701.W2 U4701.W4 U4701.W9 U4701.W11 U4701.Y1 U4701.Y3 U4701.Y5 U4701.Y8 U4701.Y10 U4701.Y12 U6581.2 U6581.4 U6582.2 Y4102.2 Y4102.4(NC#2)
V1P05EXT_FB: C28003.2 R293.2 R294.1 U33.5
VCCIN_AUX_SENSE_N: R242.1 U1JSL.AU8 U21.7
VCCIN_AUX_SENSE_P: R241.2 R439.2 R440.2 U1JSL.AU9 U21.8
VCCIN_AUX_VID0: Q26.2 R393.2 U1JSL.CP44 U17.F9 U21.18
VCCIN_AUX_VID1: Q27.2 R392.2 U1JSL.CP45 U17.B9 U21.17
VCCIN_EN: C27102.2 D39.2 R110.2 R114.2 R27124.2 R27125.2 R91326.1 U10.23
VCCIN_VIDALERT_N: R3F3.2 R3F13.1 U1JSL.AD3
VCCIN_VIDSCK: R2F3.1 U1JSL.AA2
VCCIN_VIDSOUT: R2F14.1 R3F4.2 U1JSL.AC2
VCCIO_EXT_G0: R448.2 R449.1 U38.10
VCCIO_EXT_G1: R450.2 R451.1 U38.11
VCCIO_EXT_LGATE: Q35.8 U38.8
VCCIO_EXT_MODE: R457.2 U38.1
VCCIO_EXT_PHASE: C364.2 L13.1 Q35.9 U38.7
VCCIO_EXT_RGND: R461.1 U38.12
VCCIO_EXT_UGATE: Q35.1 R460.2
VCCIO_EXT_UGATE_R: R460.1 U38.6
VCCIO_SNS_P: R1014.2 U38.13
VCCIO_SNS_R_P: R1014.1 U1JSL.AJ12
VCCST_OVERRIDE: Q25.2 U1JSL.AP2
VCCST_PWRGD_R: D35.2 R8608.1 U1JSL.AP4
ACCEL_INT_L: J24.3 TP116.1
ACOK_OD: R74.2 R1013.2 U13.A6
ALL_SYS_PWRGD: R27125.1 U17.L12
AP_BATLOW_L: R8702.2 U1JSL.BW48
AP_DPWROK: D22.2 D38.1(CATHODE) R368.1 R468.2 U1JSL.BP49
AP_EDP_BKLTEN: D23.1(CATHODE) R23.1 U1JSL.CB17
AP_FLASH_HOLD_L: R59.2 U1.14 U11.7
AP_FLASH_WP_ODL: D20.2 R153.2 U11.3(W\P\(IO2))
AP_I2C_AUDIO_SCL: R330.2 R91330.1 R91333.1 R91336.1 U1JSL.CH24
AP_I2C_AUDIO_SDA: R329.2 R91331.1 R91334.1 R91335.1 U1JSL.CJ24
AP_I2C_CAM_SCL: R328.2 TP131.1 U1JSL.CF24
AP_I2C_CAM_SDA: R327.2 TP132.1 U1JSL.CC24
AP_I2C_EMR_SCL: R324.2 TP119.1 U1JSL.CR9
AP_I2C_EMR_SDA: R316.2 TP118.1 U1JSL.CP10
AP_I2C_SUB_INT_ODL: TP97.1 U1JSL.CP6
AP_I2C_SUB_SCL: R11.2 R1030.2 TP95.1 U1JSL.CB21
AP_I2C_SUB_SDA: R2.2 R1029.2 TP96.1 U1JSL.CB19
AP_I2C_TRACKPAD_SCL_3V3: J18.4 R144.2 U1JSL.CJ11
AP_I2C_TRACKPAD_SDA_3V3: J18.5 R103.2 U1JSL.CH11
AP_I2C_TS_SCL: J23.37 R326.2 U1JSL.CL25
AP_I2C_TS_SDA: J23.36 R325.2 U1JSL.CM25
AP_PEN_DET_ODL: D32.2 R91342.2 U1JSL.CC13
AP_PROCHOT_ODL: R8606.1 U1JSL.AC4
AP_RSMRST_L: D34.2 D38.2 R340.1 RB6B1.2 U1JSL.BU49
AP_SLP_A_L: R11103.1 U1JSL.CB49
AP_SLP_S0_L: R39.2 R11108.1 U1JSL.CN41
AP_SLP_S3_L: R18.2 R11111.1 U1JSL.CB47
AP_SLP_S4_L: R19.2 R11110.1 U1JSL.BW47
AP_SLP_S5_L: TP61.1 U1JSL.BW51
AP_SLP_SUS_L: R10.2 R11109.1 U1JSL.BU51
AP_SLP_WLAN_L: TP60.1 U1JSL.CA48
AP_SPI_FLASH_CLK: R54.2 R78.2 R150.1 U11.6
AP_SPI_FLASH_CLK_R: R150.2 R11112.1 U1JSL.CH34
AP_SPI_FLASH_CS_L: R50.1 R58.2 R76.1 R313.2 U11.1
AP_SPI_FLASH_CS_L_R: R50.2 U1JSL.CE34
AP_SPI_FLASH_MISO: R56.1 U1JSL.CJ36
AP_SPI_FLASH_MISO_R: R53.2 R56.2 R77.1 U11.2
AP_SPI_FLASH_MOSI: R57.2 R79.2 R151.1 U11.5
AP_SPI_FLASH_MOSI_R: R151.2 U1JSL.CC34
AP_SPI_H1_TPM_CLK: R64.1 R390.2 U13.F9
AP_SPI_H1_TPM_CLK_R: R390.1 U1JSL.CR38
AP_SPI_H1_TPM_CS_L: R66.1 U1JSL.CM38 U13.J8
AP_SPI_H1_TPM_MISO: R395.1 U1JSL.CP39
AP_SPI_H1_TPM_MISO_R: R395.2 U13.H9
AP_SPI_H1_TPM_MOSI: R391.2 U13.C9
AP_SPI_H1_TPM_MOSI_R: R391.1 U1JSL.CL38
AP_SUB_IO_1: TP108.1 U1JSL.CF23
AP_SUB_IO_2: TP109.1 U1JSL.CJ3
AP_WP_OD: Q4.3 R51.2 U1JSL.CT11
AUX_COMP: C322.1 C323.1 U21.5
AUX_CS_DIS: R433.1 U21.1
AUX_FB: C323.2 C332.1 R438.2 R439.1 U21.6
AUX_FS: R231.2 R431.1 U21.9
AUX_LGATE: C329.1 Q33.4 R436.2
AUX_SW: C320.2 C324.2 C333.1 L12.1 Q32.1 Q32.2 Q32.3(S_3) Q33.5 U21.12
AUX_UGATE: C324.1 Q32.4 R434.2
BASE_SIXAXIS_INT_L: U15.4 U17.M2
BAT_DISABLE_OD: J14.6 Q14.3 R257.2
BAT_DISABLE_ODL: R91343.1 U13.C8
BATTERY_PRES_ODL: J14.5 R256.2 R379.2
BGATE: Q2.4 U9.6
BL_PWM: J23.24 U1JSL.CC15
BT_DISABLE_L: R113.2 U1JSL.CF21 U4100.63
C2D2_CLK_UART_DBG_TX_EC_RX_SCL: J3.6 U1.7
C2D2_CSN_UART_EC_TX_DBG_RX_SDA: J3.1 U1.1
C2D2_HOLDN_ECVREF_H1_PWRBTN_ODL: J3.4 U1.6
C2D2_MISO_UART_H1_TX_DBG_RX: J3.3 U1.4
C2D2_MOSI_UART_DBG_TX_H1_RX: J3.8 U1.9
C2D2_MUX_UART_ODL: J3.5 R155.2 U1.11 U1.21
C2D2_VREF_H1_RST_ODL: J3.2 U1.3
CBI_EEPROM_WP: R52.1 U12.7(WP) U41.4(Y)
CCD_MODE_ODL: J2.1 Q12.2 Q13.2 R75.2 U13.B1 U17.F10
CFG_RCOMP: R6F3.1 U1JSL.N1
CHARGER_BATGONE: R1012.1 U9.22
CHARGER_CMPIN: C1028.1 Q1009.1(S) R1001.1 U9.36
CHARGER_CMPOUT_OD: R1013.1 U9.30
CHARGER_COMPF: C1008.1 R1003.1 U9.12
CHARGER_COMPR: C1010.1 R1005.1 U9.13
CLK_24M_UCAM: R6D66.2 R6D67.2 U1JSL.CJ9
CLK_24M_WCAM: TP130.1 U1JSL.CK3
CLK_BIASREF: R6E3.1 U1JSL.BG3
CNV_BRI_DT: R401.2 U4100.A38
CNV_BRI_DT_R: R401.1 U1JSL.CP4
CNV_BRI_RSP: R119.2 U1JSL.CJ1
CNV_BRI_RSP_R: R119.1 U4100.A39
CNV_CLK_PCH_RX_WLAN_TX_N: U1JSL.CD41 U4100.A33
CNV_CLK_PCH_RX_WLAN_TX_P: U1JSL.CD42 U4100.A32
CNV_CLK_PCH_TX_WLAN_RX_N: U1JSL.BY44 U4100.A20
CNV_CLK_PCH_TX_WLAN_RX_P: U1JSL.BY45 U4100.A19
CNV_CLKREQ0: R422.1 U1JSL.CN23 U4100.A43
CNV_D0_PCH_RX_WLAN_TX_N: U1JSL.CE45 U4100.A35
CNV_D0_PCH_RX_WLAN_TX_P: U1JSL.CE44 U4100.A34
CNV_D0_PCH_TX_WLAN_RX_N: U1JSL.CC42 U4100.A22
CNV_D0_PCH_TX_WLAN_RX_P: U1JSL.CC41 U4100.A21
CNV_D1_PCH_RX_WLAN_TX_N: U1JSL.CG46 U4100.A37
CNV_D1_PCH_RX_WLAN_TX_P: U1JSL.CG44 U4100.A36
CNV_D1_PCH_TX_WLAN_RX_N: U1JSL.BY39 U4100.A24
CNV_D1_PCH_TX_WLAN_RX_P: U1JSL.BY41 U4100.A23
CNV_RF_RST_L: R384.1 U1JSL.CJ49 U4100.A42
CNV_RGI_DT: R6D82.1 R6D84.2 R6D85.2 R400.2 U4100.A40
CNV_RGI_DT_R: R400.1 U1JSL.CL4
CNV_RGI_RSP: R118.2 U1JSL.CP7
CNV_RGI_RSP_R: R118.1 U4100.A41
CNV_WT_RCOMP: R3808.1 U1JSL.CL52
CPU_C10_GATE_L: R355.1 R455.1 U1JSL.CL22 U17.J4 U24.D2 U26.D2
CPU_POPIRCOMP: R7D9.1 U1JSL.CK50
CPUPWRGD: TP59.1 U1JSL.AM2
CSI_RCOMP: R46.1 U1JSL.AT2
DBG_PMODE: J15.7 R5G69.1 R37.1 U1JSL.AN3
DBG_SPI_FLASH_CLK: R78.1 U1.15
DBG_SPI_FLASH_CS_L: R76.2 U1.8
DBG_SPI_FLASH_MISO: R77.2 U1.12
DBG_SPI_FLASH_MOSI: R79.1 U1.13
DDR_A_0ZQ0: R4305.1 U4301.A5
DDR_A_0ZQ1: R4306.1 U4301.A8
DDR_A_1ZQ0: R4405.1 U4401.A5
DDR_A_1ZQ1: R4406.1 U4401.A8
DDR_B_0ZQ0: R4605.1 U4601.A5
DDR_B_0ZQ1: R4606.1 U4601.A8
DDR_B_1ZQ0: R4705.1 U4701.A5
DDR_B_1ZQ1: R4706.1 U4701.A8
DDR_COMP_0: R3803.1 U1JSL.C49
DDR_COMP_1: R3809.1 U1JSL.D50
DDR_COMP_2: R3810.1 U1JSL.C48
DDR_RESET_L: C4301.1 C4401.1 C4601.1 C4701.1 R3903.2 U4301.T11 U4401.T11 U4601.T11 U4701.T11
DEBUG_I2C_INA_SCL: R1023.1 U13.J6
DEBUG_I2C_INA_SDA: R1024.1 U13.H6
DMIC0_CLK: C310.1 J23.7 R389.2
DMIC0_CLK_R: R389.1 U1JSL.CF28
DMIC0_DATA: C313.1 R397.1 U1JSL.CH28
DMIC0_DATA_R: J23.6 R397.2
DMIC1_CLK_R: TP125.1 U1JSL.CH26
DMIC1_DATA: TP126.1 U1JSL.CF26
DP_RCOMP: R6F1.1 U1JSL.E3
DRAM_RESET_N: C314.2 R3902.2 R3903.1 U1JSL.BV41
DSI_TE: TP34.1 U1JSL.AA4
EC_AP_DPWROK: R468.1 U17.L11
EC_AP_MKBP_INT_L: U1JSL.CF11 U17.K4
EC_AP_PCH_PWROK_OD: D33.2 R338.2 R339.2 U1JSL.BT50 U17.K9
EC_AP_PSYS: R202.2 U17.H9
EC_AP_PWR_BTN_ODL: TP78.1 U1JSL.BU48 U17.F11
EC_AP_RSMRST_L: R45.1 RB6B1.1 U17.K10
EC_AP_RTCRST: Q20.2 Q21.2 R9.1 U17.K5
EC_AP_SYS_PWROK: U1JSL.CC9 U17.D10
EC_AP_USB_C0_HPD: R49.1 U1JSL.CN29 U17.M11
EC_AP_USB_C1_HDMI_HPD: R402.1 U1JSL.CC36 U17.M12
EC_AP_VCCST_PWRGD_OD: R8607.2 R8608.2 U17.F8
EC_AP_WAKE_ODL: R404.2 U1JSL.CB48 U17.L5
EC_BATTERY_PRES_ODL: R379.1 U17.F3
EC_ENTERING_RW: R72.1 U13.B5 U17.E10
EC_GP_SEL_ODL: R142.2 U17.L9
EC_I2C_BATTERY_SCL: J14.4 R123.2 U17.D4
EC_I2C_BATTERY_SDA: J14.3 R121.2 U17.C4
EC_I2C_EEPROM_SCL: R128.2 U12.6 U17.G9
EC_I2C_EEPROM_SDA: R126.2 U12.5 U17.H11
EC_I2C_SENSOR_SCL: J24.5 R132.2 U15.13 U17.F12
EC_I2C_SENSOR_SDA: J24.4 R130.2 U15.14 U17.G10
EC_I2C_SUB_USB_C1_SCL: J13.37 R137.2 R91365.2 U17.K8
EC_I2C_SUB_USB_C1_SDA: J13.36 R134.2 R91364.2 U17.L8
EC_I2C_USB_C0_SCL: R140.2 U6.36 U7.3 U9.31 U9.35 U17.J10
EC_I2C_USB_C0_SDA: R139.2 U6.38 U7.4 U9.32 U9.34 U17.M7
EC_IN_RW_OD: R117.2 U1JSL.CC11 U13.A9
EC_KSI: R3003.1 R3004.1 U13.A8
EC_KSI_02: R3003.2 R3006.2 R27298.2 U17.A4
EC_KSI_03: R3004.2 R3005.2 R27297.2 U17.B3
EC_KSO_02_INV: U13.A5 U17.C5
EC_PROCHOT_ODL: R145.1 U17.G3
EC_RST_ODL: R423.1 R91319.2 U13.B3 U17.J5
EC_RST_R_L: R91319.1 U6581.3
EC_SUB_ANALOG: C249.1 R285.1 R286.1 U17.E2
EC_SUB_IO_2: C1025.1 TP107.1 U17.B2
EC_VSNS_PP3300_A: C1027.1 R317.1 U17.D2
EC_WP_OD: R52.2 U17.L10
ECH1_PACKET_MODE: R61.1 R357.2 U13.H5 U17.J6
EDP_AUX_C_N: C154.2 J23.20
EDP_AUX_C_P: C153.2 J23.19
EDP_AUX_N: C154.1 R147.1 U1JSL.E10
EDP_AUX_P: C153.1 R146.1 U1JSL.F9
EDP_HPD: J23.22 R200.1 U1JSL.CM30
EDP_TX0_C_N: C151.2 J23.16
EDP_TX0_C_P: C152.2 J23.17
EDP_TX0_N: C151.1 U1JSL.G7
EDP_TX0_P: C152.1 U1JSL.F6
EDP_TX1_C_N: C149.2 J23.3
EDP_TX1_C_P: C150.2 J23.4
EDP_TX1_N: C149.1 U1JSL.D4
EDP_TX1_P: C150.1 U1JSL.E5
EDP_TX2_C_N: C273.2 R372.1
EDP_TX2_C_P: C264.2 R373.1
EDP_TX2_N: C273.1 U1JSL.J5
EDP_TX2_P: C264.1 U1JSL.H6
EDP_TX3_C_N: C275.2 R370.1
EDP_TX3_C_P: C274.2 R371.1
EDP_TX3_N: C275.1 U1JSL.J7
EDP_TX3_P: C274.1 U1JSL.J8
EMMC_CLK: R164.2 R174.1 U1JSL.CF40
EMMC_CLK_R: R164.1 U14.M6
EMMC_CMD: R165.2 R178.2 U1JSL.CJ46
EMMC_CMD_R: R165.1 U14.M5
EMMC_D0: R156.2 R167.2 U1JSL.CJ41
EMMC_D0_R: R156.1 U14.A3
EMMC_D1: R157.2 R168.2 U1JSL.CJ45
EMMC_D1_R: R157.1 U14.A4
EMMC_D2: R158.2 R170.2 U1JSL.CJ40
EMMC_D2_R: R158.1 U14.A5
EMMC_D3: R159.2 R171.2 U1JSL.CK45
EMMC_D3_R: R159.1 U14.B2
EMMC_D4: R160.2 R172.2 U1JSL.CM43
EMMC_D4_R: R160.1 U14.B3
EMMC_D5: R161.2 R173.2 U1JSL.CL44
EMMC_D5_R: R161.1 U14.B4
EMMC_D6: R162.2 R175.2 U1JSL.CM46
EMMC_D6_R: R162.1 U14.B5
EMMC_D7: R163.2 R177.2 U1JSL.CH42
EMMC_D7_R: R163.1 U14.B6
EMMC_RCLK: R166.2 R176.1 U1JSL.CE38
EMMC_RCLK_R: R166.1 U14.H5
EMMC_RCOMP: R3812.1 U1JSL.CN50
EMMC_RST_L: R169.2 U1JSL.CH40
EMMC_RST_L_R: R80.2 R169.1 U14.K5
EMMC_VDDI_BYP: C63.1 U14.C2
EMR_INT_ODL: TP120.1 U1JSL.CR19
EMR_RESET_L: TP121.1 U1JSL.CH9
EN_BL_OD: D23.2 J23.23 R201.2 U17.E9
EN_KB_BL: J12.10 R91352.1 U5.C1 U17.G5
EN_PP1200_CAMERA: TP129.1 U1JSL.CL17
EN_PP2800_CAMERA: TP128.1 U1JSL.CN19
EN_PP3300_A: R474.1 U17.D9 U23.3
EN_PP3300_G: C290.1 R300.2 R301.1 R464.1
EN_PP3300_G_L: C243.1 D29.2 D30.2 Q16.1(S) Q17.3 Q18.2 Q23.2 R296.2
EN_PP3300_G_R: Q18.3 R298.1 R299.1 R300.1
EN_PP3300_INA_ODL: R1022.1 TP66.1 U13.J1
EN_PP3300_PANEL_S0: R22.1 U1JSL.CC17 U23.5
EN_PP3300_SD_U: R287.1 U1JSL.CN22 U34.4
EN_PP3300_TOUCH_S0: R302.1 U1JSL.CL19 U35.1
EN_PP5000_PEN: J12.13 U17.J3
EN_PP5000_U: R463.1 U17.K11
EN_SLP_Z: C300.1 Q19.2 R297.1 U17.J7
EN_SPK: R183.1 R91329.1 R91332.1 U1JSL.CH19
EN_USB_A0_VBUS: R375.1 U17.C2 U37.5
EN_USB_A1_VBUS: J12.16 U17.E11
EN_V1P05EXT: D26.2 R290.2 U33.6
EN_VCCIO_EXT: R452.1 U17.L3
EN_VCCIO_EXT_R: D40.2 R452.2 R453.2 U38.3
EN_VCCST: Q28.3 R254.1 U17.G12 U27.D2
EN_VCCST_ODL: D31.2 Q24.3 Q25.3 Q26.3 Q27.3 Q28.2 R253.2
EN_VNNEXT: D26.1 R240.2 U33.15
ESPI_CLK: R353.2 U17.M1
ESPI_CLK_R: R353.1 U1JSL.CN35
ESPI_CS_L: R11120.1 U1JSL.CR35 U17.L1
ESPI_IO0: R70.2 U17.H1
ESPI_IO0_R: R70.1 U1JSL.CP34
ESPI_IO1: R343.2 U17.J1
ESPI_IO1_R: R343.1 U1JSL.CL33
ESPI_IO2: R344.2 U17.H2
ESPI_IO2_R: R344.1 U1JSL.CL36
ESPI_IO3: R352.2 U17.K1
ESPI_IO3_R: R352.1 U1JSL.CM36
ESPI_RESET_L: R11114.1 U1JSL.CN34 U17.K3
FLASH_WP_ODL: D20.1(CATHODE) Q4.2 R152.2 U13.B6(WP_OD) U41.2
GP_C13_UART1_TXD: R4E63.2 U1JSL.CE11
GP_E14_DDI0_DDC_SDA: R6D46.2 U1JSL.CM5
GP_E16_DDI1_DDC_SDA: R6D42.2 U1JSL.CN4
GPD_1_ACPRESENT: R354.2 U1JSL.CA50
GPD_7: R7D24.1 R7D26.2 U1JSL.CB51
GPPC_A_15: R3C14.2 U1JSL.CP29
GPPC_C_1: R7D35.2 U1JSL.CN14
GPPC_C_2: R8A7.2 U1JSL.CE15
GPPC_C_8_UART0_RXD: R7D25.2 U1JSL.CL11
GPPC_C_9_UART0_TXD: R7D40.2 U1JSL.CR11
GPPC_C_10_UART0_RTSB: R4F20.1 R4F23.2 R42.1 U1JSL.CM11
GPPC_D_8_GSPI2_CS0B_UART0A_RXD: R6D29.1 R6D34.2 R30.2 R33.2 U1JSL.CM14
GPPC_D_9_GSPI2_CLK_UART0A_TXD: R1G1.1 R1G3.2 U1JSL.CM16
GPPC_D_10_GSPI2_MISO_UART0A_RTS: R6D38.1 R6D41.2 U1JSL.CR16
GPPC_D_11_GSPI2_MOSI_UART0A_CTS: R1H18.2 U1JSL.CN17
GPPC_E_6_IMGCLKOUT_3: R6C1.2 U1JSL.CH7
GPPC_E_12_IMGCLKOUT_4: R6D39.2 U1JSL.CL8
H1_AP_FLASH_SEL: Q5.2 R357.1 R360.1 U42.1
H1_AP_FLASH_SEL_ODL: Q5.3 Q6.2 R55.2
H1_AP_INT_ODL: D10.2 R62.2 U1JSL.CP48
H1_AP_INT_ODL_D: D10.1(CATHODE) U13.F8
H1_BOOT0_AP_FLASH_SEL: R69.1 R360.2 U13.J3
H1_CC1: R212.1 U13.D1
H1_CC1_R: R212.2 U8.12
H1_CC2: R213.1 U13.D2
H1_CC2_R: R213.2 U8.11
H1_CHASSIS_OPEN: C129.1 J1.2 R154.1 U13.A1
H1_EC_FLASH_SEL: R60.1 U13.J5
H1_EC_PWR_BTN_ODL: U13.B7 U17.D6
H1_KSI: R3001.1 R3002.1 U13.B4
H1_PWR_BTN_ODL: Q22.1(S) R12.2 U13.A4
H1_RST_ODL: C62.1 R71.2 U1.22 U13.G1
H1_SBU1: R214.2 R216.1 U13.E1 U13.F2
H1_SBU2: R215.2 R217.1 U13.E2 U13.F1
H1_SPI_CLK: R54.1 U13.G9
H1_SPI_CS_L: R58.1 U13.J7 U42.2
H1_SPI_MISO: R53.1 U13.J9
H1_SPI_MOSI: R57.1 U13.D9
H1_STRAP0: R63.2 U13.D8
H1_STRAP1_LID_OPEN_OD: Q15.1(S) R65.2 U13.H8
H_CATERR_N: R8602.2 U1JSL.AB3
H_PECI: R394.1 U1JSL.AM4
H_THRMTRIP_N: R8604.2 U1JSL.AR3
HDMI_DDC_SCL: R148.1 U1JSL.CF7
HDMI_DDC_SDA: R6D40.2 R149.1 U1JSL.CF5
HDMI_SEL_L: Q9.2 Q10.2 U17.H6
HP_GND_RING2: R91.1 U3.8
HP_GND_SLEEVE: R97.1 U3.7
HP_INT_ODL: R84.2 U1JSL.CJ19 U3.35
HP_JACK_DET_L: R93.1 R188.2 U3.2
HP_LEFT: R92.1 R184.1 U3.16
HP_MIC_BIAS1: R89.1 U3.39
HP_MIC_BIAS2: R95.1 U3.38
HP_MIC_N: C84.1 U3.6
HP_MIC_P: C85.1 U3.5
HP_RIGHT: R94.1 R185.1 U3.18
HP_RING1: D12.1 J16.2(R) R94.2
HP_RING2: C84.2 D15.1 J16.3 R89.2 R90.2 R91.2
HP_RING2_SENSE: R90.1 U3.14
HP_SLEEVE: C85.2 D11.1 J16.4 R95.2 R96.2 R97.2
HP_SLEEVE_SENSE: R96.1 U3.15
HP_TERM_MAKETERM: D13.1 J16.6 R93.2
HP_TIP: D14.1 J16.1 R92.2
I2S_HP_AUDIO: R332.1 U3.34
I2S_HP_BCLK: R305.1 R331.1 U3.31
I2S_HP_LRCK: R334.1 U3.32
I2S_HP_MIC: R333.1 U3.33
I2S_MCLK: R385.1 U3.29
I2S_SPK_AUDIO: R336.1 U2.13 U4.13
I2S_SPK_BCLK: R335.1 U2.7 U4.7
I2S_SPK_LRCK: R337.1 U2.11 U4.11
IBAT_N: C212.2 C1017.1 R229.2 U9.8
IBAT_P: C212.1 C1015.1 R228.1 U9.9
IMVP9_IMON: R275.2 U10.11
IMVP9_ISEN1N: C403.2 C404.1 R425.2 R427.2 R27223.2
IMVP9_ISEN1N_R: R425.1 U10.19
IMVP9_ISEN1P: R430.2 R27222.2
IMVP9_ISEN1P_R: C404.2 R427.1 R429.1 U10.20
IMVP9_ISEN2: R365.1 U10.17 U10.18
IMVP9_LGATE1: Q3.4 Q31.4 U10.28
IMVP9_PHASE1: C234.1 L27202.1 Q3.5 Q30.1 Q30.2 Q30.3(S_3) Q31.5 R27221.1 R27222.1 U10.27
IMVP9_SET1: R133.2 R135.1 U10.8
IMVP9_SET2: R141.2 R143.2 U10.7
IMVP9_SET3: R233.2 R235.1 U10.6
IMVP9_SVID_ALERT_ODL: R3F13.2 U10.3
IMVP9_SVID_CLK: R2F1.2 R2F3.2 U10.5
IMVP9_SVID_DATA: R2F14.2 R318.2 U10.4
IMVP9_TSEN: R271.1 R274.1 U10.21
IMVP9_TSEN_SET: R237.2 R264.1 R271.2 R274.2
IMVP9_UGATE1: Q30.4 U10.26
IMVP9_VREF06: R133.1 R141.1 R233.1 R237.1 R268.2 R269.1 R362.1 U10.12
IMVP9_VRHOT_L: R27113.2 U10.2(V\R\H\O\T\)
IMVP9_VRRDY_OD: R338.1 R27106.2 U10.24
INTRUDER_L: R2C20.1 R3C18.2 U1JSL.BP51
KB_BL_IN: C28026.1 R91350.1 U5.C2
KB_BL_ISET: R91353.1 U5.A1
KB_BL_LED1: CN2.1 U5.A3
KB_BL_LED2: CN2.2 U5.A2
KB_BL_PWM: J12.11 R91351.1 U5.B1(PWM) U17.K6
KB_ID: R937.2 U17.E4
KBD_PWR_BTN_GND: J17.27 J25.27 R98.2 R191.1
KBD_PWR_BTN_ODL: D16.1 J17.25 J25.25 R192.2 R193.1
KSI_00: D2.3 J17.13 J25.13 R27300.2 U17.A2
KSI_01: D16.4 J17.24 J25.24 R27299.2 U17.A3
KSI_02: D1.3 J17.17 J25.17 R3001.2 R3006.1
KSI_03: D1.4 J17.16 J25.16 R192.1 R3002.2 R3005.1
KSI_04: D17.4 J17.20 J25.20 R27296.2 U17.B4
KSI_05: D1.1 J17.19 J25.19 R27295.2 U17.C3
KSI_06: D17.2 J17.22 J25.22 R27294.2 U17.D5
KSI_07: D17.1 J17.23 J25.23 R27293.2 U17.C7
KSO_00: D1.2 J17.18 J25.18 U17.B5
KSO_01: D2.2 J17.14 J25.14 U17.B7
KSO_02: D2.4 J17.12 J25.12 U13.B8
KSO_03: D3.1 J17.11 J25.11 U17.A10
KSO_04: D2.1 J17.15 J25.15 U17.D7
KSO_05: D3.3 J17.8 J25.8 U17.A11
KSO_06: D3.2 D1001.2 J17.9 J25.9
KSO_06_D: D1001.1(CATHODE) R27301.2 U17.C8
KSO_07: D17.3 J17.21 J25.21 U17.C6
KSO_08: D4.3 J17.2 J25.2 U17.C9
KSO_09: D4.2 J17.3 J25.3 R98.1 U17.C10
KSO_10: D3.4 J17.5 J25.5 U17.E8
KSO_11: D4.1 J17.4 J25.4 U17.B10
KSO_12: D4.4 J17.1 J25.1 U17.D8
KSO_13: D16.3 J17.26 J25.26 U17.E6
KSO_14: D16.2 J17.28 J25.28 U17.K7
LATCH_FB: D28.1(CATHODE) Q17.2 Q19.3 R299.2
LED_B_ODL: R196.2 U17.A12
LED_G_ODL: R195.2 U17.G7
LED_R_ODL: R194.2 U17.B12
LID_360_L: R27330.2 R91325.1 U17.H10
LID_360_L_GMR: D2743.1 R27330.1 U6582.1
LID_OPEN: C289.1 D21.2 R1.1 R91324.1 U17.C11
LID_OPEN_GMR: D2748.1 R1.2 U6582.4
LSPK_LDO: C134.1 U2.19
LSPK_N: C28018.1 J4.3 R182.2
LSPK_P: C28017.1 J4.4 R181.2
LSPK_R_N: C138.2 R182.1 U2.22
LSPK_R_P: C137.2 R181.1 U2.27
LSPK_VCM: C133.1 U2.20(VCM)
M2_WLAN_32K: R27311.1 U4100.27
M2_WLAN_RST_L: R27312.2 U4100.44
M_A_DQ_0_0: U1JSL.M28 U4301.E11
M_A_DQ_0_1: U1JSL.J28 U4301.C11
M_A_DQ_0_2: U1JSL.P28 U4301.F11
M_A_DQ_0_3: U1JSL.H30 U4301.B9
M_A_DQ_0_4: U1JSL.H28 U4301.B11
M_A_DQ_0_5: U1JSL.J30 U4301.C9
M_A_DQ_0_6: U1JSL.M30 U4301.E9
M_A_DQ_0_7: U1JSL.P30 U4301.F9
M_A_DQ_1_0: U1JSL.E28 U4301.AA11
M_A_DQ_1_1: U1JSL.D28 U4301.V11
M_A_DQ_1_2: U1JSL.F27 U4301.U11
M_A_DQ_1_3: U1JSL.B25 U4301.Y9
M_A_DQ_1_4: U1JSL.B28 U4301.Y11
M_A_DQ_1_5: U1JSL.D25 U4301.U9
M_A_DQ_1_6: U1JSL.E25 U4301.V9
M_A_DQ_1_7: U1JSL.F25 U4301.AA9
M_A_DQ_2_0: U1JSL.M34 U4301.E4
M_A_DQ_2_1: U1JSL.J34 U4301.C4
M_A_DQ_2_2: U1JSL.P34 U4301.F4
M_A_DQ_2_3: U1JSL.H36 U4301.E2
M_A_DQ_2_4: U1JSL.H34 U4301.B4
M_A_DQ_2_5: U1JSL.J36 U4301.C2
M_A_DQ_2_6: U1JSL.P36 U4301.F2
M_A_DQ_2_7: U1JSL.M36 U4301.B2
M_A_DQ_3_0: U1JSL.E33 U4301.Y4
M_A_DQ_3_1: U1JSL.D33 U4301.AA4
M_A_DQ_3_2: U1JSL.F33 U4301.U4
M_A_DQ_3_3: U1JSL.B30 U4301.U2
M_A_DQ_3_4: U1JSL.B33 U4301.V4
M_A_DQ_3_5: U1JSL.D31 U4301.Y2
M_A_DQ_3_6: U1JSL.E30 U4301.V2
M_A_DQ_3_7: U1JSL.F30 U4301.AA2
M_A_DQS_0_DN: U1JSL.L28 U4301.E10
M_A_DQS_0_DP: U1JSL.L30 U4301.D10
M_A_DQS_1_DN: U1JSL.D26 U4301.V10
M_A_DQS_1_DP: U1JSL.C26 U4301.W10
M_A_DQS_2_DN: U1JSL.L34 U4301.E3
M_A_DQS_2_DP: U1JSL.L36 U4301.D3
M_A_DQS_3_DN: U1JSL.D32 U4301.V3
M_A_DQS_3_DP: U1JSL.C32 U4301.W3
M_A_LP4_CA0: U1JSL.E35 U4301.H2 U4301.R2
M_A_LP4_CA1: U1JSL.E39 U4301.J2 U4301.P2
M_A_LP4_CA2: U1JSL.D37 U4301.H9 U4301.R9
M_A_LP4_CA3: U1JSL.D38 U4301.H10 U4301.R10
M_A_LP4_CA4: U1JSL.B39 U4301.H11 U4301.R11
M_A_LP4_CA5: U1JSL.F38 U4301.J11 U4301.P11
M_A_LP4_CKE0_N: U1JSL.F41 U4301.J4 U4301.P4
M_A_LP4_CKE1_N: U1JSL.B41 U4301.J5 U4301.P5
M_A_LP4_CLK_DN: U1JSL.F45 U4301.J9 U4301.P9
M_A_LP4_CLK_DP: U1JSL.E46 U4301.J8 U4301.P8
M_A_LP4_CS0_N: U1JSL.D45 U4301.H4 U4301.R4
M_A_LP4_CS1_N: U1JSL.H50 U4301.H3 U4301.R3
M_B_DQ_0_0: U1JSL.K41 U4401.AA9
M_B_DQ_0_1: U1JSL.K44 U4401.Y9
M_B_DQ_0_2: U1JSL.K39 U4401.V9
M_B_DQ_0_3: U1JSL.M39 U4401.U11
M_B_DQ_0_4: U1JSL.K45 U4401.U9
M_B_DQ_0_5: U1JSL.M41 U4401.V11
M_B_DQ_0_6: U1JSL.M44 U4401.Y11
M_B_DQ_0_7: U1JSL.M45 U4401.AA11
M_B_DQ_1_0: U1JSL.P49 U4401.E9
M_B_DQ_1_1: U1JSL.P48 U4401.C9
M_B_DQ_1_2: U1JSL.P51 U4401.B9
M_B_DQ_1_3: U1JSL.L51 U4401.C11
M_B_DQ_1_4: U1JSL.N47 U4401.F9
M_B_DQ_1_5: U1JSL.K49 U4401.E11
M_B_DQ_1_6: U1JSL.L48 U4401.F11
M_B_DQ_1_7: U1JSL.K50 U4401.B11
M_B_DQ_2_0: U1JSL.T41 U4401.C4
M_B_DQ_2_1: U1JSL.T44 U4401.F4
M_B_DQ_2_2: U1JSL.T39 U4401.E4
M_B_DQ_2_3: U1JSL.V45 U4401.B2
M_B_DQ_2_4: U1JSL.T45 U4401.B4
M_B_DQ_2_5: U1JSL.V44 U4401.C2
M_B_DQ_2_6: U1JSL.V41 U4401.E2
M_B_DQ_2_7: U1JSL.V39 U4401.F2
M_B_DQ_3_0: U1JSL.W49 U4401.Y4
M_B_DQ_3_1: U1JSL.Y48 U4401.U4
M_B_DQ_3_2: U1JSL.W51 U4401.AA4
M_B_DQ_3_3: U1JSL.U51 U4401.Y2
M_B_DQ_3_4: U1JSL.W47 U4401.V4
M_B_DQ_3_5: U1JSL.U49 U4401.AA2
M_B_DQ_3_6: U1JSL.T48 U4401.U2
M_B_DQ_3_7: U1JSL.T47 U4401.V2
M_B_DQS_0_DN: U1JSL.M42 U4401.V10
M_B_DQS_0_DP: U1JSL.K42 U4401.W10
M_B_DQS_1_DN: U1JSL.M50 U4401.E10
M_B_DQS_1_DP: U1JSL.N48 U4401.D10
M_B_DQS_2_DN: U1JSL.V42 U4401.E3
M_B_DQS_2_DP: U1JSL.T42 U4401.D3
M_B_DQS_3_DN: U1JSL.V50 U4401.V3
M_B_DQS_3_DP: U1JSL.V48 U4401.W3
M_B_LP4_CA0: U1JSL.J48 U4401.H2 U4401.R2
M_B_LP4_CA1: U1JSL.F49 U4401.J2 U4401.P2
M_B_LP4_CA2: U1JSL.C46 U4401.H9 U4401.R9
M_B_LP4_CA3: U1JSL.A45 U4401.H10 U4401.R10
M_B_LP4_CA4: U1JSL.B44 U4401.H11 U4401.R11
M_B_LP4_CA5: U1JSL.C44 U4401.J11 U4401.P11
M_B_LP4_CKE0_N: U1JSL.G48 U4401.J4 U4401.P4
M_B_LP4_CKE1_N: U1JSL.D42 U4401.J5 U4401.P5
M_B_LP4_CLK_DN: U1JSL.D49 U4401.J9 U4401.P9
M_B_LP4_CLK_DP: U1JSL.E48 U4401.J8 U4401.P8
M_B_LP4_CS0_N: U1JSL.G50 U4401.H4 U4401.R4
M_B_LP4_CS1_N: U1JSL.F52 U4401.H3 U4401.R3
M_C_DQ_0_0: U1JSL.AB41 U4601.Y9
M_C_DQ_0_1: U1JSL.AB39 U4601.AA9
M_C_DQ_0_2: U1JSL.AB44 U4601.AA11
M_C_DQ_0_3: U1JSL.AD45 U4601.V11
M_C_DQ_0_4: U1JSL.AB45 U4601.Y11
M_C_DQ_0_5: U1JSL.AD44 U4601.V9
M_C_DQ_0_6: U1JSL.AD41 U4601.U11
M_C_DQ_0_7: U1JSL.AD39 U4601.U9
M_C_DQ_1_0: U1JSL.AE49 U4601.E9
M_C_DQ_1_1: U1JSL.AE48 U4601.B9
M_C_DQ_1_2: U1JSL.AE51 U4601.C9
M_C_DQ_1_3: U1JSL.AB51 U4601.F11
M_C_DQ_1_4: U1JSL.AD47 U4601.F9
M_C_DQ_1_5: U1JSL.AB49 U4601.B11
M_C_DQ_1_6: U1JSL.AB48 U4601.E11
M_C_DQ_1_7: U1JSL.AB47 U4601.C11
M_C_DQ_2_0: U1JSL.AH39 U4601.U2
M_C_DQ_2_1: U1JSL.AH45 U4601.AA2
M_C_DQ_2_2: U1JSL.AH41 U4601.V2
M_C_DQ_2_3: U1JSL.AK45 U4601.Y4
M_C_DQ_2_4: U1JSL.AH44 U4601.Y2
M_C_DQ_2_5: U1JSL.AK44 U4601.AA4
M_C_DQ_2_6: U1JSL.AK39 U4601.U4
M_C_DQ_2_7: U1JSL.AK41 U4601.V4
M_C_DQ_3_0: U1JSL.AK49 U4601.E2
M_C_DQ_3_1: U1JSL.AK48 U4601.B2
M_C_DQ_3_2: U1JSL.AK51 U4601.C2
M_C_DQ_3_3: U1JSL.AG51 U4601.E4
M_C_DQ_3_4: U1JSL.AK47 U4601.F2
M_C_DQ_3_5: U1JSL.AH49 U4601.F4
M_C_DQ_3_6: U1JSL.AG48 U4601.B4
M_C_DQ_3_7: U1JSL.AG47 U4601.C4
M_C_DQS_0_DN: U1JSL.AB42 U4601.V10
M_C_DQS_0_DP: U1JSL.AD42 U4601.W10
M_C_DQS_1_DN: U1JSL.AC50 U4601.E10
M_C_DQS_1_DP: U1JSL.AC48 U4601.D10
M_C_DQS_2_DN: U1JSL.AK42 U4601.V3
M_C_DQS_2_DP: U1JSL.AH42 U4601.W3
M_C_DQS_3_DN: U1JSL.AJ50 U4601.E3
M_C_DQS_3_DP: U1JSL.AJ48 U4601.D3
M_C_LP4_CA0: U1JSL.AP41 U4601.H2 U4601.R2
M_C_LP4_CA1: U1JSL.AT42 U4601.J2 U4601.P2
M_C_LP4_CA2: U1JSL.AT44 U4601.H9 U4601.R9
M_C_LP4_CA3: U1JSL.AT41 U4601.H10 U4601.R10
M_C_LP4_CA4: U1JSL.AT39 U4601.H11 U4601.R11
M_C_LP4_CA5: U1JSL.AT45 U4601.J11 U4601.P11
M_C_LP4_CKE0_N: U1JSL.AY42 U4601.J4 U4601.P4
M_C_LP4_CKE1_N: U1JSL.AY41 U4601.J5 U4601.P5
M_C_LP4_CLK_DN: U1JSL.AV47 U4601.J9 U4601.P9
M_C_LP4_CLK_DP: U1JSL.AV48 U4601.J8 U4601.P8
M_C_LP4_CS0_N: U1JSL.AW48 U4601.H4 U4601.R4
M_C_LP4_CS1_N: U1JSL.AY50 U4601.H3 U4601.R3
M_D_DQ_0_0: U1JSL.BF41 U4701.B4
M_D_DQ_0_1: U1JSL.BF44 U4701.C4
M_D_DQ_0_2: U1JSL.BF39 U4701.F4
M_D_DQ_0_3: U1JSL.BH45 U4701.B2
M_D_DQ_0_4: U1JSL.BF45 U4701.E4
M_D_DQ_0_5: U1JSL.BH44 U4701.C2
M_D_DQ_0_6: U1JSL.BH41 U4701.E2
M_D_DQ_0_7: U1JSL.BH39 U4701.F2
M_D_DQ_1_0: U1JSL.BF48 U4701.C9
M_D_DQ_1_1: U1JSL.BF49 U4701.F9
M_D_DQ_1_2: U1JSL.BF47 U4701.E9
M_D_DQ_1_3: U1JSL.BC51 U4701.E11
M_D_DQ_1_4: U1JSL.BF51 U4701.B9
M_D_DQ_1_5: U1JSL.BD49 U4701.F11
M_D_DQ_1_6: U1JSL.BC48 U4701.C11
M_D_DQ_1_7: U1JSL.BC47 U4701.B11
M_D_DQ_2_0: U1JSL.BM41 U4701.Y9
M_D_DQ_2_1: U1JSL.BM44 U4701.V9
M_D_DQ_2_2: U1JSL.BM39 U4701.U9
M_D_DQ_2_3: U1JSL.BP45 U4701.U11
M_D_DQ_2_4: U1JSL.BM45 U4701.AA9
M_D_DQ_2_5: U1JSL.BP44 U4701.Y11
M_D_DQ_2_6: U1JSL.BP41 U4701.AA11
M_D_DQ_2_7: U1JSL.BP39 U4701.V11
M_D_DQ_3_0: U1JSL.BM48 U4701.AA4
M_D_DQ_3_1: U1JSL.BL49 U4701.V4
M_D_DQ_3_2: U1JSL.BL47 U4701.U4
M_D_DQ_3_3: U1JSL.BJ51 U4701.Y2
M_D_DQ_3_4: U1JSL.BM51 U4701.Y4
M_D_DQ_3_5: U1JSL.BJ49 U4701.AA2
M_D_DQ_3_6: U1JSL.BH48 U4701.V2
M_D_DQ_3_7: U1JSL.BJ47 U4701.U2
M_D_DQS_0_DN: U1JSL.BH42 U4701.E3
M_D_DQS_0_DP: U1JSL.BF42 U4701.D3
M_D_DQS_1_DN: U1JSL.BE50 U4701.E10
M_D_DQS_1_DP: U1JSL.BE48 U4701.D10
M_D_DQS_2_DN: U1JSL.BM42 U4701.V10
M_D_DQS_2_DP: U1JSL.BP42 U4701.W10
M_D_DQS_3_DN: U1JSL.BK50 U4701.V3
M_D_DQS_3_DP: U1JSL.BK48 U4701.W3
M_D_LP4_CA0: U1JSL.AT51 U4701.H2 U4701.R2
M_D_LP4_CA1: U1JSL.BA49 U4701.J2 U4701.P2
M_D_LP4_CA2: U1JSL.AP50 U4701.H9 U4701.R9
M_D_LP4_CA3: U1JSL.AR49 U4701.H10 U4701.R10
M_D_LP4_CA4: U1JSL.AN51 U4701.H11 U4701.R11
M_D_LP4_CA5: U1JSL.AR47 U4701.J11 U4701.P11
M_D_LP4_CKE0_N: U1JSL.BB44 U4701.J4 U4701.P4
M_D_LP4_CKE1_N: U1JSL.AY45 U4701.J5 U4701.P5
M_D_LP4_CLK_DN: U1JSL.AV51 U4701.J9 U4701.P9
M_D_LP4_CLK_DP: U1JSL.AV49 U4701.J8 U4701.P8
M_D_LP4_CS0_N: U1JSL.AY47 U4701.H4 U4701.R4
M_D_LP4_CS1_N: U1JSL.BA51 U4701.H3 U4701.R3
MBP2_N: TP64.1 U1JSL.AF3
MBP3_N: TP65.1 U1JSL.AE4
MIPI60_BPM0_N: J15.55 R32.2 U1JSL.AE2
MIPI60_BPM1_N: J15.53 R36.2 U1JSL.AD1
MIPI60_CFG0_N: J15.19 R43.1 R405.2 R406.1 U1JSL.R2
MIPI60_CFG0R_L: J15.38 R43.2
MIPI60_CFG1_N: J15.21 R411.2 U1JSL.P3
MIPI60_CFG2_N: J15.23 U1JSL.T3
MIPI60_CFG3_N: J15.25 U1JSL.R4
MIPI60_CFG4_N: J15.27 R5M19.1 U1JSL.T1
MIPI60_CFG5_N: J15.29 U1JSL.U4
MIPI60_CFG6_N: J15.31 U1JSL.U2
MIPI60_CFG7_N: J15.33 U1JSL.W4
MIPI60_CFG8_N: J15.35 R407.2 U1JSL.N9
MIPI60_CFG9_N: J15.37 R408.2 U1JSL.N8
MIPI60_CFG10_N: J15.39 R409.2 U1JSL.R6
MIPI60_CFG11_N: J15.41 U1JSL.R10
MIPI60_CFG12_N: J15.43 R410.2 U1JSL.R12
MIPI60_CFG13_N: J15.45 R412.2 U1JSL.U8
MIPI60_CFG14_N: J15.47 U1JSL.R8
MIPI60_CFG15_N: J15.49 U1JSL.N6
MIPI60_CFG_STB0_DN: TP63.1 U1JSL.P4
MIPI60_CFG_STB0_DP: J15.13 U1JSL.P2
MIPI60_CFG_STB1_DN: TP62.1 U1JSL.U9
MIPI60_CFG_STB1_DP: J15.59 U1JSL.U10
MIPI60_CPU_JTAG_TCLK: R4.1 R279.1 U1JSL.AK3
MIPI60_CPU_JTAG_TDI: R5.1 U1JSL.AH1
MIPI60_CPU_JTAG_TDO: R6.1 R251.2 U1JSL.AJ2
MIPI60_CPU_JTAG_TMS: R17.1 U1JSL.AM1
MIPI60_CPU_JTAG_TRST_N: R21.1 U1JSL.AG2
MIPI60_GP_C10: J15.36 R42.2
MIPI60_I2C_SCL: J15.48 R41.2 TP1.1
MIPI60_I2C_SDA: J15.50 R47.2 TP2.1
MIPI60_OVERRIDE_L: D31.1(CATHODE) R3.2 R31.1
MIPI60_PCH_JTAG_TCLK: R24.1 R283.1 U1JSL.AL2
MIPI60_PCH_JTAG_TDI: R26.1 R282.2 U1JSL.AH3
MIPI60_PCH_JTAG_TDO: R27.1 R281.2 U1JSL.AJ4
MIPI60_PCH_JTAG_TMS: R28.1 R280.2 U1JSL.AM3
MIPI60_PCH_JTAG_TRST_N: R29.1 U1JSL.AG4
MIPI60_PCH_JTAGX: R25.1 U1JSL.AL4
MIPI60_POD_PRESENT1_L: J15.15 R33.1
MIPI60_POD_PRESENT2_L: J15.17 R31.2
MIPI60_PRDY_L: J15.11 U1JSL.Y3
MIPI60_PREQ_L: J15.10 U1JSL.Y1
MIPI60_PWR_BTN_L: J15.40 R44.2
MIPI60_RSMRST_L: J15.42 R45.2
MIPI60_TCK1: J15.51 R24.2
MIPI60_TCLK0: J15.3 R4.2 R25.2
MIPI60_TDI: J15.5 R5.2 R26.2
MIPI60_TDO: J15.4 R6.2 R27.2
MIPI60_TMS: J15.2 R17.2 R28.2
MIPI60_TRST_L: J15.9 R21.2 R29.2
MIPI60_TRST_PD: J15.8 R40.1
MIPI60_VREF_DEBUG: C18.2 J15.1 R38.1
MPHY_RCOMP_DN: R34.2 U1JSL.BH4
MPHY_RCOMP_DP: R34.1 U1JSL.BH2
PCH_OPIRCOMP: R6E5.1 U1JSL.BG1
PCIE_4_PCH_RX_WLAN_TX_C_N: R91327.2 U4100.36
PCIE_4_PCH_RX_WLAN_TX_C_P: R91328.2 U4100.37
PCIE_4_PCH_RX_WLAN_TX_N: R91327.1 U1JSL.BR2
PCIE_4_PCH_RX_WLAN_TX_P: R91328.1 U1JSL.BR4
PCIE_4_PCH_TX_WLAN_RX_C_N: C109.2 U4100.39
PCIE_4_PCH_TX_WLAN_RX_C_P: C110.2 U4100.40
PCIE_4_PCH_TX_WLAN_RX_N: C109.1 U1JSL.BL8
PCIE_4_PCH_TX_WLAN_RX_P: C110.1 U1JSL.BL9
PCIE_4_WLAN_REFCLK_N: U1JSL.AW8 U4100.33
PCIE_4_WLAN_REFCLK_P: U1JSL.AW6 U4100.34
PCIE_SUB_REFCLK_N: TP94.1 U1JSL.BA8
PCIE_SUB_REFCLK_P: TP93.1 U1JSL.BA9
PEN_DET_ODL: C28021.2 D32.1(CATHODE) R91349.1 U17.G4
PG_DRAM_OD: R234.1 R453.1 R27124.1 U17.H8 U22.10
PG_PP1050_ST_S_OD: TP55.1 U17.D3 U27.C1
PG_PP1800_A_OD: D27.2 R273.2 U21.19 U32.1
PG_PP1800_DRAM_U: D18.2 Q37.3 R239.2 R295.2 R465.1 R467.2
PG_PP3300_G_OD: D22.1(CATHODE) R260.2 U30.7
PG_PP5000_U_OD: R261.2 U17.B8 U31.7
PG_V1P05_OD: R13.2 R291.1 U33.7
PG_VCCIN_AUX_OD: R230.1 R240.1 U21.4
PG_VCCIO_EXT_OD: R110.1 R456.2 U17.G8 U38.2
PG_VNN_OD: R290.1 R292.1 U33.14
PLT_RST_L: R11107.1 U1JSL.CM41 U13.A2 U16.3
PP600_DRAM_U: C30.1 C31.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C4502.1 C4505.1 C4508.1 C4510.1 C4512.1 C4513.1 C4517.1 C4518.1 C4519.1 C4520.1 C4521.1 C4522.1 C4531.1 C4532.1 C4533.1 C4802.1 C4804.1 C4806.1 C4808.1 C4810.1 C4812.1 C4817.1 C4818.1 C4819.1 C4820.1 C4821.1 C4823.1 C4831.1 C4832.1 C4833.1 R243.2 R4305.2 R4306.2 R4405.2 R4406.2 R4605.2 R4606.2 R4705.2 R4706.2 U4301.AA3 U4301.AA5 U4301.AA8 U4301.AA10 U4301.B3 U4301.B5 U4301.B8 U4301.B10 U4301.D1 U4301.D5 U4301.D8 U4301.D12 U4301.F3 U4301.F10 U4301.U3 U4301.U10 U4301.W1 U4301.W5 U4301.W8 U4301.W12 U4401.AA3 U4401.AA5 U4401.AA8 U4401.AA10 U4401.B3 U4401.B5 U4401.B8 U4401.B10 U4401.D1 U4401.D5 U4401.D8 U4401.D12 U4401.F3 U4401.F10 U4401.U3 U4401.U10 U4401.W1 U4401.W5 U4401.W8 U4401.W12 U4601.AA3 U4601.AA5 U4601.AA8 U4601.AA10 U4601.B3 U4601.B5 U4601.B8 U4601.B10 U4601.D1 U4601.D5 U4601.D8 U4601.D12 U4601.F3 U4601.F10 U4601.U3 U4601.U10 U4601.W1 U4601.W5 U4601.W8 U4601.W12 U4701.AA3 U4701.AA5 U4701.AA8 U4701.AA10 U4701.B3 U4701.B5 U4701.B8 U4701.B10 U4701.D1 U4701.D5 U4701.D8 U4701.D12 U4701.F3 U4701.F10 U4701.U3 U4701.U10 U4701.W1 U4701.W5 U4701.W8 U4701.W12
PP600_DRAM_U_R: C233.1 R243.1 R443.1 U22.20
PP850_VCCLDOSTD: C491.1 U1JSL.CN49
PP1050_INTERNAL: U1JSL.BU36 U1JSL.BW36 U1JSL.CA36
PP1050_OUT_PCH: C29.1 C242.1 R37.2 R38.2 U1JSL.BB2 U1JSL.BC3 U27.A2 U27.B2
PP1050_OUT_PLL: U1JSL.AY4 U1JSL.BB4
PP1050_ST_CT: TP10.1 U27.C2
PP1050_ST_S: C11.1 R2F1.1 R3F3.1 R3F4.1 R318.1 R8602.1 R8604.1 R8607.1 U1JSL.AY2 U1JSL.BA1 U1JSL.BA3 U27.A1 U27.B1(VOUT#2)
PP1050_STG_S0: C3423.1 R251.1 R280.1 R281.1 R282.1 R8603.1 R8609.1 U1JSL.AW1 U1JSL.AW3
PP1050_V1P05EXT: C287.1 C317.1 C28002.2 C28003.1 L11.2 R293.1 U1JSL.BP18 U1JSL.BT18 U1JSL.BU18 U1JSL.BW18 U1JSL.CA18
PP1050_VCCIO_EXT: C325.2 C326.1 C327.2 C328.1 C330.2 C331.1 C334.2 C335.2 C336.1 C338.2 C340.2 C342.2 C344.2 C346.2 C347.2 C348.2 C349.2 C352.2 C355.2 C359.2 C365.1 C367.1 C368.1 C369.1 C378.1 J15.12 L13.2 R32.1 R36.1 R405.1 R407.1 R408.1 R409.1 R410.1 R411.1 R412.1 U1JSL.AJ15 U1JSL.AM15 U1JSL.AR15 U1JSL.AU15 U1JSL.AW15
PP1050_VCCSTG_OUT: U1JSL.BE34 U1JSL.BG34 U1JSL.BJ34 U1JSL.BK34
PP1100_DRAM_U: C10.1 C14.1 C15.1 C16.2 C17.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C54.1 C55.1 C57.1 C241.1 C382.1 C387.1 C393.1 C412.1 C413.1 C414.2 C416.1 C418.1 C419.1 C422.1 C424.2 C426.1 C4523.1 C4524.1 C4525.1 C4526.1 C4527.1 C4528.1 C4529.1 C4530.1 C4534.1 C4535.1 C4536.1 C4537.1 C4538.1 C4539.1 C4540.1 C4541.1 C4822.1 C4824.1 C4825.1 C4826.1 C4827.1 C4828.1 C4829.1 C4830.1 C4834.1 C4835.1 C4836.1 C4837.1 C4838.1 C4839.1 C4840.1 C4841.1 R245.2 R3902.1 U1JSL.AB34 U1JSL.AB36 U1JSL.AC34 U1JSL.AC36 U1JSL.AE34 U1JSL.AE36 U1JSL.AF38 U1JSL.AG36 U1JSL.AH34 U1JSL.AH36 U1JSL.AK34 U1JSL.AK36 U1JSL.AM34 U1JSL.AM36 U1JSL.AM38 U1JSL.AP36 U1JSL.AR34 U1JSL.AR36 U1JSL.AU34 U1JSL.AU36 U1JSL.AV38 U1JSL.AW34 U1JSL.AW36 U1JSL.AY34 U1JSL.AY36 U1JSL.BB36 U1JSL.BD36 U1JSL.BD38 U1JSL.BE36 U1JSL.BG36 U1JSL.BJ36 U1JSL.BK36 U1JSL.BK38 U1JSL.BM36 U1JSL.BP36 U1JSL.P38 U1JSL.U34 U1JSL.U36 U1JSL.V34 U1JSL.V36 U1JSL.Y34 U1JSL.Y36 U1JSL.Y38 U26.A2 U26.B2 U4301.A4 U4301.A9 U4301.AB4 U4301.AB9 U4301.F5 U4301.F8 U4301.G2 U4301.H1 U4301.H5 U4301.H8 U4301.H12 U4301.K1 U4301.K3 U4301.K10 U4301.K12 U4301.N1 U4301.N3 U4301.N10 U4301.N12 U4301.R1 U4301.R5 U4301.R8 U4301.R12 U4301.T2 U4301.U5 U4301.U8 U4401.A4 U4401.A9 U4401.AB4 U4401.AB9 U4401.F5 U4401.F8 U4401.G2 U4401.H1 U4401.H5 U4401.H8 U4401.H12 U4401.K1 U4401.K3 U4401.K10 U4401.K12 U4401.N1 U4401.N3 U4401.N10 U4401.N12 U4401.R1 U4401.R5 U4401.R8 U4401.R12 U4401.T2 U4401.U5 U4401.U8 U4601.A4 U4601.A9 U4601.AB4 U4601.AB9 U4601.F5 U4601.F8 U4601.G2 U4601.H1 U4601.H5 U4601.H8 U4601.H12 U4601.K1 U4601.K3 U4601.K10 U4601.K12 U4601.N1 U4601.N3 U4601.N10 U4601.N12 U4601.R1 U4601.R5 U4601.R8 U4601.R12 U4601.T2 U4601.U5 U4601.U8 U4701.A4 U4701.A9 U4701.AB4 U4701.AB9 U4701.F5 U4701.F8 U4701.G2 U4701.H1 U4701.H5 U4701.H8 U4701.H12 U4701.K1 U4701.K3 U4701.K10 U4701.K12 U4701.N1 U4701.N3 U4701.N10 U4701.N12 U4701.R1 U4701.R5 U4701.R8 U4701.R12 U4701.T2 U4701.U5 U4701.U8
PP1100_DRAM_U_R: C235.1 C236.1 C237.1 C238.1 C379.1 C380.1 C381.1 L14.2 R245.1 R445.1 U22.5 U22.19
PP1100_PLLOC_CT: TP9.1 U26.C2
PP1100_PLLOC_S0: C474.1 U1JSL.BV38 U1JSL.BV39 U26.A1 U26.B1(VOUT#2)
PP1240_VCCDPHY: C489.1 U1JSL.CM48
PP1800_A: C89.1 C90.1 C92.1 C239.1 C386.1 C407.1 C28004.1 C28010.1 J23.1 J24.1 R82.1 R84.1 R85.1 R86.1 R130.1 R132.1 R180.1 R187.1 R246.1 R276.2 R316.1 R324.1 R327.1 R328.1 R329.1 R330.1 R491.1 R1029.1 R1030.1 R91338.1 R91363.1 U15.5(VDDIO) U15.8 U15.12 U24.A2 U24.B2 U40.A2
PP1800_A_R: C268.1 C269.1 C270.1 C271.1 C401.1 L17.2 R276.1 R277.1
PP1800_AGSH_CT: TP8.1 U24.C2
PP1800_AGSH_S0: C3406.2 R247.2 U1JSL.AV2 U1JSL.AV4
PP1800_CLKLDO: L3601.2 R7.2 R8.1 U1JSL.CN1 U1JSL.CN3
PP1800_DRAM_U: C49.1 C4501.1 C4503.1 C4504.1 C4506.1 C4507.1 C4509.1 C4511.1 C4514.1 C4515.1 C4516.1 C4801.1 C4803.1 C4805.1 C4807.1 C4809.1 C4811.1 C4813.1 C4814.1 C4815.1 C4816.1 Q36.2 R244.2 U4301.F1 U4301.F12 U4301.G4 U4301.G9 U4301.T4 U4301.T9 U4301.U1 U4301.U12 U4401.F1 U4401.F12 U4401.G4 U4401.G9 U4401.T4 U4401.T9 U4401.U1 U4401.U12 U4601.F1 U4601.F12 U4601.G4 U4601.G9 U4601.T4 U4601.T9 U4601.U1 U4601.U12 U4701.F1 U4701.F12 U4701.G4 U4701.G9 U4701.T4 U4701.T9 U4701.U1 U4701.U12
PP1800_EC_G: C116.1 C120.1 C122.1 R136.1 U17.F1
PP1800_G: C298.1 R136.2 U36.5(VOUT)
PP1800_HP: C71.1 C74.2 R82.2 U3.20
PP1800_HP_IO: C78.1 R86.2 U3.30
PP1800_LSPK_A: C132.2 C136.2 R180.2 U2.12 U2.18
PP1800_RSPK_A: C140.2 C144.2 R187.2 R91361.1 U4.12 U4.18
PP1800_SOC_A: C488.1 L3601.1 R6D66.1 R6D84.1 R6D88.1 R7.1 R105.1 R314.1 R392.1 R393.1 R491.2 U1JSL.BW23 U1JSL.BW25 U1JSL.BW26 U1JSL.CA23 U1JSL.CA25 U1JSL.CA26 U1JSL.CA28
PP1800_SSD_A: C65.1 C67.1 R80.1 R167.1 R168.1 R170.1 R171.1 R172.1 R173.1 R175.1 R177.1 R178.1 R246.2 U14.C6 U14.M4 U14.N4 U14.P3 U14.P5
PP1800A_HP: C77.1 C81.2 R85.2 R88.2 U3.10
PP3000_RTC: C1A6.1 C486.2 C487.1 D24.1(CATHODE) R3C18.1 R3C22.1 R3C23.1 U1JSL.CL49
PP3300_A: D9.1 Q28.1(S) R2.1 R3.1 R11.1 R30.1 R48.2 R51.1 R62.1 R83.1 R103.1 R114.1 R117.1 R144.1 R230.2 R234.2 R248.2 R253.1 R273.1 R291.2 R292.2 R317.2 R320.1 R322.1 R339.1 R403.1 R456.1 R466.1 R467.1 R27106.1 R27313.1 R91317.1
PP3300_A_R: R248.1 R249.1 R250.1 R252.1 R488.1 U23.13 U23.14
PP3300_AP_FLASH: C20.1 D9.3(CATHODE) R59.1 R153.1 U1.10 U11.8
PP3300_CAMERA_USER: C28011.1 J23.13 J23.14 R27313.2
PP3300_DISPLAY_S0: C315.1 C316.1 J23.27 J23.28 J23.29 R201.1 R304.2
PP3300_EC_G: C111.1 C113.1 C115.1 C117.1 C119.1 C121.1 C123.1 C124.2 FB1.2 R121.1 R123.1 R125.2 R126.1 R128.1 R134.1 R137.1 R139.1 R140.1 R142.1 R256.1 R423.2 R937.1 R27291.2 R27293.1 R27294.1 R27295.1 R27296.1 R27297.1 R27298.1 R27299.1 R27300.1 R27301.1 U17.A7 U17.B1 U17.D12 U17.H12 U17.L4 U17.M8 U17.M10
PP3300_G: C21.1 C240.1 C272.1 C293.1 C294.1 C295.1 C28015.2 DS1.2 DS1.4 DS1.6 Q1009.2 R81.1 R125.1 R152.1 R260.1 R261.1 R266.2 R303.1 R398.1 R399.1 R91337.1 U12.8 U23.1 U23.2 U23.4 U23.6 U23.7 U34.6 U35.4 U35.5 U36.1 U41.5
PP3300_G_R: C257.2 C259.1 C261.1 C308.1 C309.1 C402.1 L15.2 R266.1 U30.10(VOUT)
PP3300_H1_G: C50.1 C51.1 C52.1 C53.1 C60.1 C61.1 C28016.2 J1.1 Q6.1(S) Q15.2 Q22.2 R12.1 R55.1 R63.1 R65.1 R67.2 R71.1 R73.1 R74.1 R75.1 R399.2 U13.A7 U13.B2 U13.E9 U13.H1 U13.J4 U42.5
PP3300_HP_MIC: C72.1 C75.2 R83.2 U3.40
PP3300_HP_VBAT: C68.1 R81.2 R188.1 U3.1
PP3300_LDO_Z: C130.2 C187.1 C1045.2 C28022.1 C28023.1 D24.2 J12.4 Q18.1(S) R99.1 R155.1 R204.1 R255.1 R296.1 R301.2 R91364.1 R91365.1 U1.5(VCC) U9.25 U6582.3(VDD)
PP3300_MIPI60: J15.52 R41.1 R47.1 R48.1
PP3300_PANEL_S0: R304.1 U23.8 U23.9(VOUT2#2)
PP3300_PP1800_VCCPGPPR: R6D88.2 R35.2 U1JSL.BW28
PP3300_SD_U: C158.1 C159.1 J9.4 R289.2
PP3300_SD_U_R: R289.1 U34.1(OUT)
PP3300_SOC_A: C12.2 C13.1 C48.1 R1G3.1 R1H18.1 R3C14.1 R4E63.1 R4F23.1 R6C1.1 R6D34.1 R6D39.1 R6D40.1 R6D41.1 R6D42.1 R6D46.1 R6D67.1 R6D85.1 R7D25.1 R7D26.1 R7D35.1 R7D40.1 R8A7.1 R20.1 R35.1 R249.2 R354.1 R380.1 R381.1 R382.1 R383.1 R404.1 R413.1 R415.1 R417.1 R419.1 R424.1 R8702.1 U1JSL.BW30 U1JSL.BW31 U1JSL.BW33 U1JSL.BW34 U1JSL.CA30 U1JSL.CA31 U1JSL.CA33 U1JSL.CA34 U1JSL.CK48
PP3300_SSD_A: C64.1 C66.1 R250.2 U14.E6 U14.F5 U14.J10 U14.K9
