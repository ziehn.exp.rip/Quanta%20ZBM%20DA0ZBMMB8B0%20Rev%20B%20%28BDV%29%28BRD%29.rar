# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_D_DQ_3_0: length 30.7
  TOP w0.088: v1(109.41,46.74) 109.41,47.35 109.98,47.92 109.98,48.63 110.53,49.18 110.53,50.19 110.87,50.53 110.87,50.86 110.8,50.93 110.8,51.21 110.84,51.25 110.9,51.37 110.93,51.5 110.88,51.66 110.9,51.83 111.01,51.98 111.01,51.98 U1JSL.BM48
  TOP w0.089: U4701.AA4 v1(94.25,36.31)
  IN1 w0.135: v1(109.41,46.74) 109.39,46.77 108.06,46.77 104.41,43.11 95.93,43.11 92.89,40.07 92.89,37.26 93.85,36.31 v1(94.25,36.31)
M_D_DQ_3_1: length 31.7
  TOP w0.088: v1(109.08,46.32) 109.6,46.32 110.51,47.23 110.51,48.66 110.89,49.04 110.89,50.05 111.22,50.38 111.22,50.81 111.37,51 111.37,51.18 111.18,51.48 U1JSL.BL49
  TOP w0.089: U4701.V4 v1(96.15,36.31)
  IN1 w0.102: v1(96.15,36.31) 95.88,36.31 95.48,36.7 93.91,36.7 93.23,37.38 93.23,37.48
  IN1 w0.135: 93.23,37.48 93.23,39.94 96.05,42.76 104.56,42.76 108.22,46.41 108.99,46.41 v1(109.08,46.32)
M_D_DQ_3_2: length 32.5
  TOP w0.088: U1JSL.BL47 111.47,52.5 111.47,51.67 111.44,51.6 111.44,51.41 111.55,51.23 111.55,51.18 111.55,50.94 111.55,50.94 111.42,50.77 111.42,50.77 111.4,50.75 111.4,50.31 111.07,49.97 111.07,48.96 110.69,48.58 110.69,47.16 109.11,45.58 v1(108.31,45.58)
  TOP w0.089: v1(96.93,36.31) 96.93,36.32 97.18,36.57 U4701.U4
  IN1 w0.089: v1(96.93,36.31) 96.92,36.31 96.92,36.31 96.9,36.31 96.5,36.71 95.89,36.71 95.61,36.98 94.75,36.98 93.86,37.87
  IN1 w0.135: 93.86,37.87 93.64,38.09 93.64,39.87 96.19,42.42 105.15,42.42 v1(108.31,45.58)
M_D_DQ_3_3: length 25.6
  TOP w0.088: v1(110.66,46.06) 110.66,46.63 111.57,47.54 111.57,47.76 112.64,48.83 112.64,50.15 112.43,50.36 112.43,50.88 112.43,50.88 112.43,51.11 U1JSL.BJ51
  TOP w0.089: U4701.Y2 95.5,38.71 v1(95.51,38.71)
  IN1 w0.135: v1(95.51,38.71) 95.98,39.18 96.28,39.18 96.57,39.46 96.57,40.3 96.92,40.65 105.88,40.65 110.66,45.43 v1(110.66,46.06)
M_D_DQ_3_4: length 31.3
  TOP w0.088: U1JSL.BM51 111.05,51.06 111.05,50.45 110.71,50.12 110.71,49.11 110.16,48.56 v1(110.16,47.49)
  TOP w0.089: U4701.Y4 v1(94.9,36.31)
  IN1 w0.135: v1(110.16,47.49) 108.2,47.49 104.16,43.44 95.79,43.44 92.52,40.17 92.52,37.06 93.68,35.9 94.49,35.9 v1(94.9,36.31)
M_D_DQ_3_5: length 26.3
  TOP w0.088: v1(109.87,45.33) 109.87,46.09 111.4,47.62 111.4,47.84 112.47,48.91 112.47,50.07 112.25,50.29 112.25,50.84 112.11,51.06 112.1,51.2 112.18,51.37 112.19,51.39 112.26,51.54 U1JSL.BJ49
  TOP w0.089: U4701.AA2 v1(94.87,38.71)
  IN1 w0.135: v1(109.87,45.33) 109.87,45.11 105.74,40.98 96.78,40.98 95.67,39.88 95.67,39.39 95.41,39.12 95.28,39.12 v1(94.87,38.71)
M_D_DQ_3_6: length 26.5
  TOP w0.088: v1(111.1,46.48) 111.67,46.48 112.29,47.09 112.29,47.97 113,48.69 113,50.3 112.79,50.5 112.79,50.51 112.79,50.77 112.79,50.77 112.79,50.89 112.86,50.96 112.86,51.28 112.74,51.47 112.74,51.85 112.7,51.88 U1JSL.BH48
  TOP w0.089: U4701.V2 v1(96.93,38.71)
  IN1 w0.135: v1(111.1,46.48) 111.1,45.39 106,40.29 97.07,40.29 96.93,40.15 v1(96.93,38.71)
M_D_DQ_3_7: length 26.9
  TOP w0.088: v1(111.84,47.24) 111.84,47.78 112.82,48.76 112.82,50.22 112.61,50.44 112.61,50.84 112.61,50.84 112.61,50.97 112.68,51.03 112.68,51.23 112.56,51.42 112.56,51.77 112.56,51.78 112.55,51.78 112.54,51.81 112.5,51.9 112.27,52.12 112.27,52.36 112.46,52.54 U1JSL.BJ47
  TOP w0.089: v1(97.56,38.71) 97.55,38.71 U4701.U2
  IN1 w0.135: v1(111.84,47.24) 111.84,46.56 111.52,46.24 111.52,45.35 106.12,39.94 99.12,39.94 98.67,39.49 98.67,39.3 99.06,38.92 99.06,38.73 98.86,38.53 98.67,38.53 98.29,38.91 98.1,38.91 97.9,38.71 v1(97.56,38.71)
M_D_DQS_0_DN: length 24.9
  TOP w0.089: U4701.E3 v1(104.66,37.1) ; U1JSL.BH42 v1(112.97,55.29)
  IN5 w0.089: v1(112.97,55.29) 113.31,54.95 113.31,53.07 113.09,52.85 112.86,52.85 111.83,51.81 111.83,50.29 107.59,46.04 107.59,44.99 108.27,44.31 108.27,39.09 107.36,38.18 105.25,38.18 104.89,37.83 104.89,37.33 v1(104.66,37.1)
M_D_DQS_0_DP: length 24.9
  TOP w0.089: U4701.D3 v1(105.31,37.1) ; U1JSL.BF42 v1(113.88,55.29)
  IN5 w0.089: v1(105.31,37.1) 105.1,37.32 105.1,37.74 105.33,37.98 107.44,37.98 108.48,39.01 108.48,44.39 107.79,45.08 107.79,45.96 112.03,50.2 112.03,51.73 112.95,52.64 113.18,52.64 113.51,52.98 113.51,54.92 v1(113.88,55.29)
M_D_DQS_1_DN: length 26.5
  TOP w0.088: v1(112.49,46.01) 112.49,46.7 114.51,48.72 114.51,49.94 114.31,50.14 114.31,50.74 114.15,50.98 114.15,51.47 U1JSL.BE50
  TOP w0.089: U4701.E10 v1(105.3,31.51)
  IN3 w0.122: v1(105.3,31.51) 105.3,31.69 105.52,31.92 106.05,31.92 106.26,32.13 108.93,32.13 111.43,34.62 111.43,44.24 112.68,45.49 112.68,45.82 v1(112.49,46.01)
M_D_DQS_1_DP: length 26.5
  TOP w0.088: U1JSL.BE48 114.2,52.08 114.43,51.53 114.43,51.43 114.33,51.23 114.33,51.03 114.38,50.96 114.49,50.79 114.49,50.74 114.49,50.74 114.49,50.21 114.69,50.02 114.69,48.65 112.9,46.86 v1(112.9,46.47)
  TOP w0.089: U4701.D10 v1(105.95,31.51)
  IN3 w0.122: v1(105.95,31.51) 106.35,31.91 109.02,31.91 111.65,34.53 111.65,44.15 112.9,45.4 v1(112.9,46.47)
M_D_DQS_2_DN: length 38.8
  TOP w0.089: U4701.V10 v1(96.23,31.51) ; U1JSL.BM42 v1(111.17,54.63)
  IN3 w0.089: 93.09,32.2 93.11,32.19 93.11,32.16 93.47,31.8 94.41,31.8 94.86,32.24 95.78,32.24 95.99,32.04 95.99,31.75 v1(96.23,31.51) ; 109.95,51.27 109.96,51.29 109.96,51.31 110.18,51.53 110.18,52.14 110.81,52.78 110.81,54.54 110.9,54.63 v1(111.17,54.63)
  IN3 w0.122: 109.95,51.27 108.6,49.92 108.6,49.24 102.61,43.25 96.44,43.25 92.96,39.76 92.96,32.34 93.09,32.2
M_D_DQS_2_DP: length 38.8
  TOP w0.089: U4701.W10 v1(95.58,31.51) ; U1JSL.BP42 v1(110.27,54.63)
  IN3 w0.089: 92.94,32.05 92.95,32.03 92.98,32.03 93.4,31.62 94.49,31.62 94.93,32.06 95.32,32.06 95.32,32.06 95.71,32.06 95.81,31.96 95.81,31.74 v1(95.58,31.51) ; v1(110.27,54.63) 110.44,54.63 110.63,54.43 110.63,52.85 110,52.22 110,51.6 109.84,51.44 109.84,51.44 109.84,51.44 109.81,51.44 109.8,51.42
  IN3 w0.122: 109.8,51.42 108.39,50.01 108.39,49.33 102.52,43.46 96.35,43.46 92.74,39.85 92.74,32.25 92.94,32.05
M_D_DQS_3_DN: length 29.9
  TOP w0.088: U1JSL.BK50 111.74,51.47 111.74,50.97 111.82,50.86 111.9,50.73 111.9,50.31 111.5,49.91 111.5,49.23 111.65,49.08 v1(111.65,48.79)
  TOP w0.089: v1(96.26,37.91) 96.26,37.9 U4701.V3
  IN1 w0.089: v1(96.26,37.91) 96.01,37.66 96.01,37.48 95.82,37.29 94.82,37.29 94.32,37.79 94.32,39.14 94.32,39.15 94.32,39.17
  IN1 w0.109: v1(111.65,48.79) 111.7,48.84 111.85,48.84 112.03,48.65 112.03,48.42 105.41,41.8 96.45,41.8 94.32,39.67 94.32,39.17
M_D_DQS_3_DP: length 29.9
  TOP w0.088: v1(111.95,49.24) 111.76,49.24 111.68,49.33 111.68,49.83 112.08,50.23 112.08,50.79 111.99,50.92 111.99,50.92 111.96,50.96 111.92,51.03 111.92,51.24 112.01,51.42 112.01,51.54 111.96,51.65 111.78,51.83 U1JSL.BK48
  TOP w0.089: U4701.W3 v1(95.63,37.91)
  IN1 w0.089: 94.51,39.17 94.51,39.15 94.5,39.14 94.5,37.86 94.9,37.47 95.75,37.47 95.83,37.55 95.83,37.71 v1(95.63,37.91)
  IN1 w0.109: v1(111.95,49.24) 111.95,49.01 112.22,48.73 112.22,48.34 105.49,41.61 96.53,41.61 94.51,39.59 94.51,39.17
M_D_LP4_CA0: length 42.9
  TOP w0.088: v1(118.33,49.73) 118.29,49.77 118.29,51.06 U1JSL.AT51
  TOP w0.089: U4701.H2 v1(103.35,37.91) ; U4701.R2 v1(98.14,37.91)
  IN1 w0.135: v1(118.33,49.73) 117.56,49.73 117.06,50.23 116.2,50.23 116.07,50.37 116.07,50.76 116.43,51.12 116.43,51.44 116.13,51.75 115.62,51.75 115.36,51.48 115.36,49.89 115.49,49.76 115.58,49.76 115.72,49.62 115.72,49.35 115.58,49.21 115.49,49.21 115.36,49.08 115.36,47.77 108.16,40.57 108.16,39.89 108.03,39.76 107.47,39.76 107.33,39.63 107.33,39.35 107.47,39.22 108.03,39.22 108.16,39.08 108.16,38.81 107.56,38.21 104.09,38.21 103.9,38.39 103.9,38.65 103.77,38.79 100.87,38.79 v1(100.77,38.89)
  IN3 w0.089: v1(98.14,37.91) 98.14,38.71 98.32,38.89 98.46,38.89 98.55,38.97 98.55,39.43 98.64,39.52 98.81,39.52 98.91,39.43 98.91,38.97 99,38.89 99.17,38.89 99.26,38.97 99.26,39.02 99.35,39.11 99.53,39.11 99.62,39.02 99.62,38.97 99.71,38.89 99.88,38.89 99.97,38.97 99.97,39.02 100.06,39.11 100.24,39.11 100.46,38.89 v1(100.77,38.89) 102.37,38.89 102.48,38.78 102.6,38.78 102.98,39.16 103.13,39.16 103.51,38.78 103.51,38.55 103.42,38.46 103.3,38.46 103.11,38.65 102.98,38.65 102.85,38.53 102.85,38.4 v1(103.35,37.91)
M_D_LP4_CA1: length 38.8
  TOP w0.088: v1(116.32,48.6) 115.93,48.99 115.93,50.24 116.05,50.36 116.05,50.81 116.2,51 116.2,51.18 116.01,51.48 U1JSL.BA49
  TOP w0.089: U4701.J2 v1(102.7,37.91) ; U4701.P2 v1(98.8,37.91)
  IN1 w0.135: v1(116.32,48.6) 115.84,48.12 115.84,47.79 115.39,47.33 115.39,46.47 114.33,45.41 113.48,45.41 108.49,40.43 108.49,38.63 107.76,37.89 103.9,37.89 103.4,38.39 101.55,38.39 v1(100.77,37.62)
  IN3 w0.089: v1(98.8,37.91) 98.47,38.24 98.47,38.59 98.55,38.68 98.73,38.68 98.82,38.59 98.82,38.4 98.91,38.31 99.09,38.31 99.18,38.4 99.18,38.59 99.27,38.68 99.44,38.68 99.53,38.59 99.53,38.4 99.62,38.31 99.8,38.31 99.89,38.4 99.89,38.57 99.98,38.66 100.13,38.66 100.22,38.57 100.22,38.28 99.84,37.9 99.84,37.49 99.98,37.35 100.5,37.35 v1(100.77,37.62) 100.77,37.53 101.23,37.07 101.57,37.07 101.73,37.23 101.73,37.45 101.65,37.54 101.18,37.54 101.11,37.61 101.11,37.77 101.19,37.85 101.33,37.85 101.42,37.93 101.42,38.06 101.25,38.23 101.25,38.58 101.34,38.67 101.48,38.67 101.57,38.58 101.57,38.39 101.66,38.3 101.84,38.3 101.93,38.39 101.93,38.58 102.01,38.67 102.34,38.67 102.7,38.3 v1(102.7,37.91)
M_D_LP4_CA2: length 42.5
  TOP w0.088: v1(119.27,48.25) 119.62,48.6 119.62,48.95 119.46,49.11 119.46,50.48 119.04,50.89 118.98,50.98 118.98,51.47 U1JSL.AP50
  TOP w0.089: U4701.R9 v1(98.15,33.11) ; U4701.H9 v1(103.34,33.12)
  IN1 w0.089: 103.52,31.76 103.4,31.76 103.24,31.92 101.63,31.92 101.35,31.63 v1(100.75,31.63) ; v1(119.27,48.25) 118.99,48.25 118.61,47.87 118.36,47.87 118.21,47.72 118.21,46.71 115.98,44.48 115.98,44.11
  IN1 w0.135: 115.98,44.11 115.98,43.89 112.46,40.36 112.46,36.5 107.84,31.88 107.05,31.88 106.79,32.14 106.51,32.14 106.25,31.88 105.97,31.88 105.71,32.14 105.41,32.14 104.78,31.51 104.29,31.51 104.03,31.76 103.52,31.76
  IN3 w0.089: v1(98.15,33.11) 98.53,32.73 99.75,32.73 99.84,32.64 99.84,31.48 100.07,31.26 100.37,31.26 v1(100.75,31.63) 101.18,31.2 101.46,31.2 101.62,31.36 101.62,32.47 101.84,32.69 102.91,32.69 v1(103.34,33.12)
M_D_LP4_CA3: length 40.9
  TOP w0.088: v1(118.41,48.78) 118.41,48.79 118.83,49.21 118.83,50.06 118.47,50.43 118.47,50.81 118.61,51 118.61,51.18 118.43,51.48 U1JSL.AR49
  TOP w0.089: U4701.R10 v1(98.81,32.3) ; U4701.H10 v1(102.71,32.3)
  IN1 w0.089: v1(102.71,32.3) 102.33,32.69 101.71,32.69 101.55,32.53 101.55,32.2 101.32,31.97 101.04,31.97 100.83,32.18 100.55,32.18 99.71,32.69 99.2,32.69 v1(98.81,32.3) ; v1(118.41,48.78) 118.03,48.39 118.03,46.78 115.72,44.46 115.72,44.09 115.49,43.87
  IN1 w0.102: 100.94,32.07 101.19,32.33 101.19,33.69 101.35,33.85 101.95,33.85 102.3,33.5 102.86,33.5 102.91,33.54 103.4,33.54
  IN1 w0.135: 115.49,43.87 112.13,40.5 112.13,36.64 110.64,35.15 110.45,35.15 110.36,35.24 110.17,35.24 109.98,35.05 109.98,34.86 110.07,34.77 110.07,34.58 109.87,34.39 109.68,34.39 109.6,34.47 109.41,34.47 109.22,34.28 109.22,34.09 109.3,34 109.3,33.81 109.11,33.62 108.92,33.62 108.83,33.71 108.64,33.71 108.45,33.51 108.45,33.32 108.54,33.24 108.54,33.05 108.01,32.53 104.39,32.53 104.16,32.76 104.16,33.41 104.02,33.54 103.4,33.54
M_D_LP4_CA4: length 40.2
  TOP w0.088: v1(119.14,47.71) 119.22,47.71 119.96,48.45 119.96,48.98 119.78,49.16 119.78,51.01 U1JSL.AN51
  TOP w0.089: U4701.R11 v1(98.8,30.7) ; U4701.H11 v1(102.67,30.71)
  IN1 w0.089: v1(119.14,47.71) 119.14,47.49 118.83,47.17 118.83,46.66 118.61,46.43 118.44,46.43 116.59,44.58 116.59,44.08 ; v1(98.8,30.7) 99.26,30.24 100.75,30.24 100.89,30.38 101.82,30.38 101.88,30.33 102.29,30.33 v1(102.67,30.71)
  IN1 w0.135: 100.75,30.24 100.75,29.64 100.89,29.5 102.91,29.5 103.68,30.26 107.74,30.26 108.45,30.98 108.45,31.36 108.65,31.55 109.03,31.55 109.22,31.74 109.22,32.13 109.41,32.32 109.79,32.32 110.04,32.56 110.04,32.95 110.23,33.14 110.61,33.14 113.18,35.7 113.18,40.12 116.59,43.52 116.59,44.08
M_D_LP4_CA5: length 38.3
  TOP w0.088: U1JSL.AR47 118.71,52.5 118.71,51.67 118.68,51.6 118.68,51.41 118.79,51.23 118.79,51.18 118.79,50.94 118.79,50.94 118.67,50.77 118.67,50.77 118.65,50.75 118.65,50.5 119.01,50.13 119.01,49.14 118.85,48.97 118.85,48.1 118.64,47.89 v1(118.64,47.51)
  TOP w0.089: U4701.P11 v1(99.44,31.5) ; U4701.J11 v1(102.05,31.52)
  IN1 w0.089: v1(102.05,31.52) 101.66,31.52 101.34,31.2 100.74,31.2 ; 103.4,31.36 102.81,31.36 102.58,31.12 101.84,31.12 101.41,30.7 100.87,30.7 100.74,30.84 100.74,31.2 ; 100.74,31.2 99.74,31.2 v1(99.44,31.5) ; v1(118.64,47.51) 118.44,47.32 118.44,46.69 116.29,44.53 116.29,44.11
  IN1 w0.135: 103.4,31.36 103.73,31.36 103.98,31.1 107.54,31.1 112.79,36.36 112.79,40.22 116.29,43.72 116.29,44.11
M_D_LP4_CKE0_N: length 37.7
  TOP w0.089: U4701.P4 v1(98.8,36.3) ; U1JSL.BB44 v1(115.68,53.97) ; U4701.J4 v1(102.7,36.29)
  IN1 w0.135: v1(115.68,53.97) 115.68,52.94 114.96,52.21 114.96,51.49 114.82,51.35 114.48,51.35 114.34,51.22 114.34,50.95 114.48,50.81 114.82,50.81 114.96,50.68 114.96,50.41 114.82,50.27 114.48,50.27 114.34,50.14 114.34,49.87 114.48,49.73 114.82,49.73 114.96,49.6 114.96,49.32 114.82,49.19 114.48,49.19 114.34,49.06 114.34,48.78 114.48,48.65 114.82,48.65 114.96,48.51 114.96,47.84 106.98,39.86 106.98,39.26 106.84,39.12 101.54,39.12 101.28,39.38 100.43,39.38 100.22,39.17 100.22,36.26 v1(100.77,35.71)
  IN3 w0.089: v1(98.8,36.3) 99.02,36.07 99.39,35.92 100.56,35.92 v1(100.77,35.71) 102.12,35.71 v1(102.7,36.29)
M_D_LP4_CKE1_N: length 37.4
  TOP w0.089: U4701.P5 v1(99.45,35.5) ; U4701.J5 v1(102.71,35.48) ; U1JSL.AY45 v1(116.58,53.3)
  IN1 w0.089: v1(116.58,53.3) 116.58,52.11 118.76,49.93 118.76,49.54 118.54,49.32 117.03,49.32 116.85,49.14 116.85,46.46 116.6,46.22 ; v1(99.45,35.5) 99.86,35.1 102.32,35.1 v1(102.71,35.48)
  IN1 w0.102: 101.07,35.1 101.08,35.09 101.08,34.87 101.17,34.78 102.87,34.78 103.13,35.03 104.54,35.03
  IN1 w0.135: 116.6,46.22 114.77,44.39 113.98,44.39 110.69,41.1 110.69,37.89 107.84,35.03 104.54,35.03
M_D_LP4_CLK_DN: length 37.1
  TOP w0.088: v1(117.28,47.77) 117.72,48.2 117.72,49.21 117.54,49.39 117.54,49.66 117.54,49.66 117.54,50.07 117.27,50.34 117.27,50.36 117.26,50.36 117.26,50.92 117.22,50.96 117.22,51.15 U1JSL.AV51
  TOP w0.089: U4701.P9 v1(98.81,33.12) ; U4701.J9 v1(102.7,33.11)
  IN1 w0.089: 104.56,34.53 104.54,34.53 104.53,34.52 100.32,34.52 100.04,34.25 100.04,33.81 100.26,33.59 100.54,33.59 100.78,33.35 v1(100.78,33.25) ; v1(117.28,47.77) 117.32,47.8 117.58,47.8 117.67,47.71 117.67,46.95 115.18,44.46 115.18,44.3 114.64,43.76 114.55,43.76 114.54,43.76 114.52,43.76
  IN1 w0.109: 114.52,43.76 114.24,43.76 111.31,40.84 111.31,36.98 110.39,36.05 109.84,36.05 108.32,34.53 104.56,34.53
  IN3 w0.089: v1(102.7,33.11) 102.4,33.41 102.4,33.42 102.32,33.49 101.02,33.49 v1(100.78,33.25) 100.57,33.47 100.52,33.47 99.16,33.47 v1(98.81,33.12)
M_D_LP4_CLK_DP: length 37.1
  TOP w0.088: v1(117.28,48.3) 117.54,48.56 117.54,49.13 117.36,49.32 117.36,49.99 117.09,50.26 117.09,50.28 117.08,50.29 117.08,50.83 117.08,50.83 117.08,50.84 117.07,50.87 116.94,51.06 116.93,51.2 117.09,51.53 U1JSL.AV49
  TOP w0.089: U4701.J8 v1(102.71,33.89) ; U4701.P8 v1(98.81,33.92)
  IN1 w0.089: 104.56,34.34 104.54,34.34 104.53,34.35 100.39,34.35 100.22,34.18 100.22,33.88 100.34,33.77 100.65,33.77 v1(100.78,33.91) ; 114.52,43.57 114.54,43.57 114.55,43.58 114.71,43.58 115.36,44.23 115.36,44.39 117.85,46.88 117.85,47.79 117.66,47.98 117.6,47.98 v1(117.28,48.3)
  IN1 w0.109: 114.52,43.57 114.32,43.57 111.5,40.76 111.5,36.9 110.47,35.86 109.92,35.86 108.39,34.34 104.56,34.34
  IN3 w0.089: v1(102.71,33.89) 102.71,33.82 102.55,33.67 102.4,33.67 101.02,33.67 v1(100.78,33.91) 100.52,33.64 99.09,33.64 v1(98.81,33.92)
M_D_LP4_CS0_N: length 36.9
  TOP w0.088: v1(116.32,49.69) 116.23,49.78 116.23,50.74 116.25,50.77 116.25,50.77 116.38,50.94 116.38,50.94 116.38,51.18 116.38,51.23 116.27,51.41 116.27,51.6 116.3,51.67 116.3,52.5 U1JSL.AY47
  TOP w0.089: U4701.R4 v1(98.16,36.3) ; U4701.H4 v1(103.34,36.29)
  IN1 w0.089: v1(98.16,36.3) 98.56,35.9 99.72,35.9 100.62,35.32 101.16,35.32 ; 101.16,35.32 101.16,35.71 101.41,36.14 101.54,36.38 101.88,36.71 102.38,36.71 ; 101.16,35.32 101.36,35.32 101.66,35.54 102.17,35.9 102.84,35.9 103.18,35.56 103.31,35.56 103.47,35.72 103.47,35.85 103.34,35.98 v1(103.34,36.29) ; v1(116.32,49.69) 116.33,49.69 116.67,49.35 116.67,46.74 116.39,46.46
  IN1 w0.135: 116.39,46.46 114.67,44.74 113.86,44.74 110.36,41.23 110.36,38.03 108.67,36.34 107.83,36.34 107.45,36.71 102.38,36.71
M_D_LP4_CS1_N: length 39.2
  TOP w0.088: U1JSL.BA51 115.88,51.06 115.88,50.44 115.75,50.31 115.75,48.59 v1(116.32,48.03)
  TOP w0.089: U4701.H3 v1(102.71,37.11) ; U4701.R3 v1(98.81,37.11)
  IN1 w0.102: 104.41,37.54 103.59,37.54 103.54,37.5 103.2,37.5 101.29,37.5 v1(100.77,36.98)
  IN1 w0.135: v1(116.32,48.03) 116.32,47.86 115.77,47.31 115.77,46.39 114.47,45.1 113.63,45.1 110.02,41.49 110.02,40.36 109.89,40.22 108.96,40.22 108.83,40.09 108.83,39.82 108.96,39.68 109.89,39.68 110.02,39.55 110.02,39.28 109.89,39.14 108.96,39.14 108.83,39.01 108.83,38.73 108.96,38.6 109.89,38.6 110.02,38.47 110.02,38.17 109.4,37.54 107.38,37.54 107.24,37.41 107.24,37.23 107.11,37.1 106.84,37.1 106.7,37.23 106.7,37.41 106.57,37.54 104.41,37.54
  IN3 w0.089: v1(102.71,37.11) 102.71,36.81 102.62,36.72 101.67,36.72 101.58,36.63 101.58,36.04 101.49,35.95 101.27,35.95 101.18,36.04 101.18,36.63 101.09,36.72 101.03,36.72 v1(100.77,36.98) 100.42,36.64 100.42,36.22 100.34,36.13 100.13,36.13 100.04,36.22 100.04,36.83 99.95,36.92 99.76,36.92 99.51,36.67 98.95,36.67 98.81,36.81 v1(98.81,37.11)
MBP2_N: length 5
  TOP w0.089: TP64.1 122.93,75.02 123.27,74.68 123.27,74.09 122.96,73.78 122.96,73.12 122.77,72.93 122.77,72.5 U1JSL.AF3
MBP3_N: length 1.7
  TOP w0.089: U1JSL.AE4 122.8,71.68 v2(122.8,71.12)
  BOTTOM w0.117: TP65.1 122.77,71.17 122.8,71.15 v2(122.8,71.12)
MIPI60_BPM0_N: length 61.5
  TOP w0.089: 122.94,77.62 123.32,77.25 123.32,75.65 123.45,75.53 123.45,74.02 123.14,73.71 U1JSL.AE2
  TOP w0.109: v2(122.19,83.58) 122.01,83.4 122.01,82.22 122.88,81.36 122.88,77.68 122.94,77.62
  IN4 w0.089: v2(80.44,76.82) 81.74,78.12 84.55,78.12 87.99,81.56 93.85,81.56 95.11,82.82 102.64,82.82 102.99,82.47 110.22,82.47 111.34,83.59 118.28,83.59 119.01,82.87 121.48,82.87 v2(122.19,83.58)
  BOTTOM w0.114: J15.55 82.69,75.92 82.09,75.92 81.92,75.75 80.81,75.75 R32.2 80.85,76.13 80.85,76.41 v2(80.44,76.82)
MIPI60_BPM1_N: length 64.8
  TOP w0.089: U1JSL.AD1 123.56,73.62 123.8,73.86 123.8,74.67 124,74.86 124,75.4
  TOP w0.109: 124,75.4 124,76.31 123.73,76.58 123.73,77.54 123.35,77.92 123.35,81.55 123.08,81.83 123.08,82.24 123.87,83.03 R36.2 123.87,83.85 v2(123.72,84.01)
  IN4 w0.089: v2(123.72,84.01) 122.08,84.01 121.13,83.06 119.21,83.06 118.46,83.81 111.29,83.81 110.16,82.68 103.05,82.68 102.72,83.01 94.96,83.01 93.71,81.75 87.83,81.75 84.43,78.36 80.84,78.36 v2(79.31,76.82)
  BOTTOM w0.114: v2(79.31,76.82) 79.31,76.73 80.54,75.5 82.42,75.5 J15.53
MIPI60_CFG0_N: length 95.3
  TOP w0.089: 128.84,77.07 R406.1 128.84,76.07 127.4,74.63 127.4,72.87 U1JSL.R2
  TOP w0.109: 128.84,77.07 R405.2 128.84,78.11 128.95,78.21
  TOP w0.117: v2(129.19,84.78) 129.11,84.7 129.11,82.68 129.53,82.26 129.53,79.64 128.95,79.05 128.95,78.21
  IN1 w0.097: v2(75.7,69.14) 75.94,68.9 76.5,68.9 77.41,69.81 84.35,69.81 85.84,71.29 89.21,71.29 89.6,71.69 90.06,71.69 v2(90.32,71.44)
  IN4 w0.089: v2(129.19,84.78) 128.83,85.15 128.31,85.15 128.03,84.87 128.03,84.72 125.88,82.56 123.53,82.56 122.69,81.72 118.53,81.72 117.82,82.43 111.81,82.43 110.65,81.28 102.56,81.28 102.17,81.67 95.64,81.67 94.38,80.41 88.53,80.41 81.81,73.7 81.81,73.55 78.68,70.42 77.59,70.42 77.34,70.67 76.6,70.67 75.7,69.77 v2(75.7,69.14)
  BOTTOM w0.114: v2(75.7,69.14) 76.07,68.77 76.57,68.77 76.73,68.92 77.03,68.92 J15.19 ; R43.1 91.44,71.69 91.09,71.35 90.4,71.35 v2(90.32,71.44)
MIPI60_CFG0R_L: length 12.9
  BOTTOM w0.114: J15.38 84.16,68.83 84.19,69.32 87.46,73.58 89.18,73.58 90.44,72.32 91.23,72.32 91.41,72.14 R43.2 v4(92.63,72.14)
MIPI60_CFG1_N: length 78.6
  TOP w0.089: 129.38,77.62 129.38,76.06 128.3,74.99 128.3,73.92 128.06,73.68 128.06,73.14 127.85,72.93 127.85,72.48 U1JSL.P3
  TOP w0.109: 129.38,77.62 129.38,77.98 129.42,78.02 129.42,78.82 130.01,79.4 130.01,82.89 v4(129.95,82.94) 129.95,83.87 130.45,84.36 v2(130.45,84.77)
  IN4 w0.089: v2(76.29,69.28) 76.47,69.28 76.73,69.53 78.6,69.53 82.38,73.31 82.38,73.46 88.75,79.84 94.65,79.84 95.92,81.1 101.93,81.1 102.32,80.71 110.92,80.71 112.06,81.85 117.6,81.85 118.3,81.15 126.1,81.15 129.09,84.15 129.82,84.15 v2(130.45,84.77)
  BOTTOM w0.114: R411.2 75.49,70.08 v2(76.29,69.28) 77.39,69.28 J15.21
MIPI60_CFG2_N: length 76.4
  TOP w0.089: 127.4,74.99 127.23,74.82 127.23,73.15 127,72.93 127,72.48 U1JSL.T3
  TOP w0.109: 127.4,74.99 127.65,75.25 127.65,76.06 128.11,76.52 128.11,78.55 129.29,79.74 129.29,82.09 128.87,82.51 v4(128.67,82.51) 128.67,82.95 128.87,83.15 128.87,84.49 v2(128.59,84.77)
  IN4 w0.089: v2(128.59,84.77) 128.59,84.19 125.94,81.53 118.45,81.53 117.76,82.23 111.87,82.23 110.73,81.09 102.48,81.09 102.09,81.48 95.73,81.48 94.47,80.22 88.6,80.22 82,73.62 82,73.47 78.63,70.1 77.64,70.1 77.27,70.47 76.78,70.47 76.5,70.19 v2(76.5,69.84)
  BOTTOM w0.114: J15.23 77.68,69.68 77.26,69.68 77.11,69.53 76.8,69.53 v2(76.5,69.84)
MIPI60_CFG3_N: length 76.2
  TOP w0.089: 129.13,77.62 129.13,76.1 127.58,74.56 127.58,73.13 127.66,73.04 127.66,72.69 127.39,72.42 U1JSL.R4
  TOP w0.109: 129.13,77.62 129.13,78.06 129.19,78.12 129.19,78.95 129.77,79.54 129.77,82.4 129.35,82.82 129.35,83.96 v4(129.57,84.18) 129.81,84.42 v2(129.81,84.77)
  IN4 w0.089: v2(129.81,84.77) 129.38,84.34 129.01,84.34 126.02,81.34 118.37,81.34 117.68,82.04 111.98,82.04 110.84,80.9 102.4,80.9 102.01,81.29 95.83,81.29 94.57,80.03 88.68,80.03 82.19,73.54 82.19,73.39 78.58,69.78 77.49,69.78 77.21,70.06 v2(77.08,70.06)
  BOTTOM w0.114: v2(77.08,70.06) 77.09,70.07 78,70.07 J15.25
MIPI60_CFG4_N: length 71.8
  TOP w0.089: U1JSL.T1 127.05,73.35 127.05,75.02 127.34,75.32 127.34,75.37
  TOP w0.109: v2(127.53,84.77) 127.53,84.52 v4(128.26,83.79) 128.26,83.36 128.03,83.14 128.03,82.48 128.44,82.07 128.9,82.07 129.06,81.92 129.06,80.94 129,80.88 R5M19.1 129,79.79 127.87,78.67 127.87,76.56 127.34,76.03 127.34,75.37
  IN4 w0.089: v2(127.53,84.77) 127.5,84.77 125.49,82.76 123.46,82.76 122.61,81.91 118.61,81.91 117.89,82.64 111.74,82.64 110.58,81.48 102.63,81.48 102.24,81.86 95.53,81.86 94.28,80.61 88.45,80.61 81.62,73.77 81.62,73.63 78.92,70.93 v2(77.74,70.93)
  BOTTOM w0.114: J15.27 78.06,70.68 77.99,70.68 v2(77.74,70.93)
MIPI60_CFG5_N: length 73.5
  TOP w0.089: U1JSL.U4 126.68,72.16 126.68,72.56 126.81,72.69 126.81,73.04 126.73,73.13 126.73,73.43 126.87,73.57 126.87,75.22 127.09,75.44 127.09,75.5
  TOP w0.109: v2(126.94,84.77) v4(126.94,84) 126.94,83.7 127.62,83.02 127.62,81.68 128.14,81.17 128.14,79.26 127.64,78.77 127.64,76.63 127.09,76.08 127.09,75.5
  IN4 w0.089: v2(77.11,71.05) 77.36,71.31 78,71.31 78.12,71.18 78.9,71.18 81.43,73.71 81.43,73.85 88.37,80.8 94.2,80.8 95.46,82.05 102.32,82.05 102.71,81.67 110.5,81.67 111.66,82.83 117.97,82.83 118.69,82.1 122.53,82.1 123.38,82.95 125.13,82.95 v2(126.94,84.77)
  BOTTOM w0.114: v2(77.11,71.05) 77.41,71.36 78.04,71.36 J15.29
MIPI60_CFG6_N: length 70.5
  TOP w0.089: U1JSL.U2 126.54,73.49 126.69,73.65 126.69,75.37
  TOP w0.109: v2(126.36,84.77) 126.33,84.75 126.33,83.81 127.39,82.75 127.39,81.58 127.9,81.07 127.9,79.36 127.4,78.86 127.4,76.67 126.69,75.96 126.69,75.37
  IN4 w0.089: v2(78,71.82) 78.38,71.44 78.89,71.44 81.23,73.79 81.23,73.93 88.29,80.99 94.09,80.99 95.34,82.24 102.4,82.24 102.79,81.86 110.42,81.86 111.58,83.02 118.05,83.02 118.77,82.29 122.45,82.29 123.31,83.15 124.73,83.15 v2(126.36,84.77)
  BOTTOM w0.114: v2(78,71.82) 78.53,71.28 78.89,71.28 J15.31
MIPI60_CFG7_N: length 70
  TOP w0.089: 126.47,74.65 126.51,74.61 126.51,73.73 126.35,73.56 126.35,73.13 126.27,73.04 126.27,72.7 126.39,72.58 126.39,72.32 126.09,72.02 U1JSL.W4
  TOP w0.109: v2(125.77,84.77) 125.77,83.98 127.15,82.61 127.15,81.48 127.66,80.97 127.66,79.46 127.17,78.96 127.17,76.74 126.47,76.04 126.47,74.65
  IN4 w0.089: v2(125.77,84.77) 124.34,83.34 123.23,83.34 122.38,82.48 118.85,82.48 118.12,83.21 111.5,83.21 110.34,82.05 102.87,82.05 102.48,82.43 95.27,82.43 94.01,81.18 88.21,81.18 81.04,74.01 81.04,73.86 79,71.82 v2(78.63,71.82)
  BOTTOM w0.114: J15.33 79.05,71.81 78.64,71.81 v2(78.63,71.82)
MIPI60_CFG8_N: length 61.9
  TOP w0.089: U1JSL.N9 128.55,69.64 v2(128.82,69.91)
  IN1 w0.097: v2(128.82,69.91) 128.84,69.91 129.23,70.3 129.23,71.77 128.3,72.7 128.02,72.7 126.81,73.91 118.66,73.91 118.06,74.51 110.46,74.51 109.9,73.95 106.46,73.95 104.37,76.05 102.1,76.05 101.05,74.99 98.9,74.99 98.66,75.23 93.32,75.23 91.73,73.65 88.91,73.65 88.8,73.75 84.13,73.75 83.76,73.38 78.74,73.38 v2(78.12,72.76)
  BOTTOM w0.114: v2(78.12,72.76) 77.48,72.76 R407.2 77.74,72.32 78.72,72.32 78.96,72.09 79.49,72.09 J15.35
MIPI60_CFG9_N: length 59.4
  TOP w0.089: U1JSL.N8 128.57,70.3 v2(128.82,70.55)
  IN1 w0.097: v2(128.82,70.55) 129.02,70.75 129.02,71.66 128.26,72.43 128.01,72.43 126.73,73.71 118.58,73.71 117.98,74.31 110.54,74.31 109.98,73.75 106.33,73.75 104.35,75.74 102.23,75.74 101.19,74.7 98.85,74.7 98.52,75.03 93.4,75.03 91.81,73.45 88.99,73.45 88.42,72.88 85.05,72.88 84.66,73.27 83.96,73.27 83.86,73.18 79.18,73.18 v2(78.76,72.76)
  BOTTOM w0.114: R408.2 78.29,73.23 v2(78.76,72.76) 78.76,72.74 79.14,72.36 79.92,72.36 80.71,71.71 J15.37
MIPI60_CFG10_N: length 54.4
  TOP w0.089: U1JSL.R6 127.69,71.16 v1(127.92,71.39)
  IN1 w0.097: v2(79.4,72.78) 81.19,72.78 81.24,72.73 83.03,72.73 83.47,72.28 88.71,72.28 89.16,72.73 91.93,72.73 92.68,73.47 94.36,73.47 94.61,73.23 96.84,73.23 97.26,73.66 100.61,73.66 100.89,73.38 105.18,73.38 105.41,73.14 117.85,73.14 117.88,73.12 126.36,73.12 127.92,71.56 v1(127.92,71.39)
  BOTTOM w0.114: J15.39 80.05,72.89 79.51,72.89 v2(79.4,72.78) 78.76,73.43 78.76,73.5 R409.2
MIPI60_CFG11_N: length 52.6
  TOP w0.089: v1(127,69.07) 127.11,69.18 U1JSL.R10
  IN1 w0.097: v1(127,69.07) 127.35,69.41 127.35,71.57 126.19,72.72 117.71,72.72 117.69,72.74 105.2,72.74 104.96,72.98 100.5,72.98 100.04,72.53 97.29,72.53 97.04,72.78 96.05,72.78 95.46,72.19 94.66,72.19 93.92,72.94 92.71,72.94 92.1,72.33 89.39,72.33 88.95,71.89 85.45,71.89 85.25,71.69 82.57,71.69 82.18,71.29 v2(82.18,71.02)
  BOTTOM w0.114: v2(82.18,71.02) 82.33,71.18 82.33,71.65 J15.41
MIPI60_CFG12_N: length 54.6
  TOP w0.089: v1(127.91,69.05) 127.91,68.98 U1JSL.R12
  IN1 w0.097: v2(83.07,72.09) 83.07,72.09 88.82,72.09 89.26,72.53 92.02,72.53 92.76,73.27 94.21,73.27 94.45,73.03 96.92,73.03 97.35,73.46 98.45,73.46 99.08,72.83 100.07,72.83 100.41,73.18 105.07,73.18 105.3,72.95 117.77,72.95 117.79,72.92 126.28,72.92 127.55,71.65 127.55,69.41 v1(127.91,69.05)
  BOTTOM w0.114: v2(83.07,72.09) 82.47,72.09 81.72,72.85 J15.43 80.47,73.77 79.56,73.77 R410.2
MIPI60_CFG13_N: length 54.8
  TOP w0.089: U1JSL.U8 126.66,70.5 v1(126.99,70.83)
  IN1 w0.097: v2(82.77,71.22) 82.8,71.22 82.97,71.4 85.25,71.4 85.54,71.69 89.03,71.69 89.47,72.13 92.18,72.13 92.79,72.74 93.83,72.74 94.6,71.97 95.53,71.97 96.05,72.48 96.83,72.48 98.22,71.09 99.66,71.09 100.05,71.47 100.05,72.25 100.58,72.78 104.87,72.78 105.13,72.52 125.04,72.52 126.73,70.83 v1(126.99,70.83)
  BOTTOM w0.114: v2(82.77,71.22) 82.8,71.22 83.49,71.92 83.49,72.26 83.24,72.51 82.86,72.51 81.98,73.23 80.92,74.1 80.31,74.1 R412.2
MIPI60_CFG14_N: length 51
  TOP w0.089: U1JSL.R8 127.59,70.5 v1(127.92,70.83)
  IN1 w0.097: v2(83.67,72.78) 83.97,72.48 88.62,72.48 89.07,72.93 91.86,72.93 93.56,74.64 98.06,74.64 98.43,74.27 101.36,74.27 102.44,75.34 104.07,75.34 106.07,73.34 117.93,73.34 117.96,73.32 126.56,73.32 128.27,71.61 128.27,71.18 v1(127.92,70.83)
  BOTTOM w0.114: J15.47 83.44,72.75 v2(83.67,72.78)
MIPI60_CFG15_N: length 50.8
  TOP w0.089: v1(128.67,71.44) 128.67,71.26 U1JSL.N6
  IN1 w0.097: v1(128.67,71.44) 128.67,71.49 126.65,73.51 118.5,73.51 117.9,74.11 110.62,74.11 110.06,73.56 106.21,73.56 104.23,75.54 102.33,75.54 101.28,74.48 98.68,74.48 98.33,74.83 93.48,74.83 91.9,73.25 89.09,73.25 88.52,72.68 84.46,72.68 v2(84.26,72.88)
  BOTTOM w0.114: v2(84.26,72.88) 83.93,73.2 83.59,73.2 83.58,73.21 J15.49
MIPI60_CFG_STB0_DN: length 6.8
  TOP w0.089: 129.85,77.62 129.85,77.14 129.74,77.03 129.74,75.92 128.66,74.84 128.66,73.64 128.43,73.41 128.43,73.13 128.51,73.04 128.51,72.69 128.24,72.42 U1JSL.P4
  TOP w0.109: 129.85,77.62 129.85,77.73 TP63.1
MIPI60_CFG_STB0_DP: length 79.7
  TOP w0.089: U1JSL.P2 128.24,73.61 128.48,73.85 128.48,74.91 129.56,75.99 129.56,77.13 129.62,77.19 129.62,77.62
  TOP w0.109: v2(131.08,84.77) v4(131.08,84.1) 130.45,83.46 130.45,82.1 130.24,81.9 130.24,79.31 129.66,78.72 129.66,77.92 129.62,77.88 129.62,77.62
  IN4 w0.089: v2(131.08,84.77) 130.27,83.96 129.17,83.96 126.18,80.96 118.22,80.96 117.52,81.66 112.14,81.66 111,80.52 102.24,80.52 101.85,80.91 96.11,80.91 94.83,79.64 88.83,79.64 82.57,73.38 82.57,73.23 78.68,69.34 77.04,69.34 76.35,68.64 75.48,68.64 75.2,68.36 v2(74.87,68.36)
  BOTTOM w0.114: v2(74.87,68.36) 75.25,67.98 75.86,67.98 76.78,67.06 J15.13
MIPI60_CFG_STB1_DN: length 1.7
  TOP w0.089: v1(126.99,70.17) 126.66,69.84 U1JSL.U9
  BOTTOM w0.114: v1(126.99,70.17) 127.14,70.17 127.65,69.66 TP62.1
MIPI60_CFG_STB1_DP: length 55.6
  TOP w0.089: U1JSL.U10 126.56,69.18 v1(126.99,69.61)
  IN1 w0.097: v2(82.77,70.63) 82.77,70.6 82.85,70.53 84.78,70.53 85.74,71.49 89.11,71.49 89.55,71.93 93.07,71.93 93.34,71.66 93.54,71.66 93.87,71.99 94.26,71.99 94.56,71.69 95.75,71.69 96.07,71.37 97.54,71.37 98.03,70.88 99.74,70.88 100.25,71.39 100.25,72.17 100.66,72.58 104.78,72.58 105.03,72.32 124.73,72.32 126.53,70.53 126.53,70.08 v1(126.99,69.61)
  BOTTOM w0.114: v2(82.77,70.63) 83.44,71.3 83.44,71.42 83.84,71.82 83.84,71.87 85.17,73.2 85.17,75.1 J15.59
MIPI60_CPU_JTAG_TCLK: length 72
  TOP w0.089: 121.23,77.62 121.23,74.92 121.41,74.74 121.41,73.83 121.26,73.67 121.26,73.14 121.05,72.93 121.05,72.48 U1JSL.AK3
  TOP w0.109: 121.23,77.62 121.23,80.67 119.67,82.23 119.54,82.23 119.27,82.49 119.17,82.49 118.61,83.06 R279.1 118.61,84.04 118.08,84.57 v2(118.08,84.77)
  IN2 w0.097: v2(70.83,67.14) 71.72,68.03 72.33,68.03 73.25,68.95 73.88,68.95 75.23,70.3 75.23,71.39 79.29,75.45 82.97,75.45 83.55,76.04 84.98,76.04 86.68,77.74 100.74,77.74 101.14,78.13 101.14,79.25 103.04,81.15 108.79,81.15 111.14,83.5 116.8,83.5 v2(118.08,84.77)
  BOTTOM w0.114: R4.1 71.27,65.67 71.27,66.46 70.83,66.89 v2(70.83,67.14)
MIPI60_CPU_JTAG_TDI: length 68.8
  TOP w0.089: U1JSL.AH1 121.94,73.35 121.94,77.51 121.94,77.52
  TOP w0.109: v2(120.39,84.77) 120.26,84.64 120.26,83.5 120.41,83.35 120.41,83.12 v4(120.67,82.87) 120.67,82.23 121.94,80.96 121.94,77.52
  IN2 w0.097: v2(120.39,84.77) 120.29,84.67 120.29,84.14 118.86,82.71 111.46,82.71 109.12,80.36 105.8,80.36 103.5,78.06 102.22,78.06 101.11,76.94 87.26,76.94 85.49,75.17 83.89,75.17 83.38,74.66 82.56,74.66 75.02,67.12 72.38,67.12 v2(72.3,67.04)
  BOTTOM w0.114: R5.1 72.3,66.98 v2(72.3,67.04)
MIPI60_CPU_JTAG_TDO: length 80.2
  TOP w0.089: U1JSL.AJ2 121.43,73.56 121.59,73.71 121.59,74.96 121.46,75.09 121.46,77.62
  TOP w0.109: 121.46,77.62 121.46,80.77 119.74,82.49 119.61,82.49 119.35,82.75 R251.2 119.35,82.95 118.92,83.39 118.92,84.11 118.66,84.36 v2(118.66,84.77)
  IN2 w0.097: v2(69.08,64.5) 69.08,64.83 72.08,67.83 72.41,67.83 73.22,68.64 73.85,68.64 75.46,70.24 75.46,71.29 79.42,75.26 83.07,75.26 83.6,75.79 85.02,75.79 86.77,77.54 100.86,77.54 102.05,78.73 103.28,78.73 105.51,80.96 108.87,80.96 111.22,83.3 117.24,83.3 118.66,84.72 v2(118.66,84.77)
  BOTTOM w0.114: R6.1 74.02,59.02 73.57,59.02 69.08,63.51 v2(69.08,64.5)
MIPI60_CPU_JTAG_TMS: length 15.1
  TOP w0.089: U1JSL.AM1 120.2,73.31 120.2,74.93 120.5,75.23 120.5,77.25 120.28,77.47 120.28,77.62
  TOP w0.109: R17.1 114.25,83.22 116.12,83.22 116.6,82.74 v4(116.88,82.74) 116.88,82.46 117.42,81.93 117.87,81.93 118.81,80.99 119.57,80.99 120.28,80.28 120.28,77.62
MIPI60_CPU_JTAG_TRST_N: length 69.7
  TOP w0.089: U1JSL.AG2 122.3,72.87 122.3,77.28 122.41,77.39
  TOP w0.109: 122.41,77.39 122.41,81.16 121.46,82.11 121.46,83.86 121.77,84.18 121.77,84.53 v2(121.53,84.77)
  IN2 w0.097: v2(73.3,67.75) 73.78,68.24 74.01,68.24 75.91,70.14 75.91,71.08 79.68,74.86 83.27,74.86 83.8,75.39 85.18,75.39 86.93,77.14 101.02,77.14 102.2,78.31 103.46,78.31 105.71,80.56 109.04,80.56 111.38,82.9 118.67,82.9 120.01,84.24 120.01,85.06 120.1,85.15 121.15,85.15 v2(121.53,84.77)
  BOTTOM w0.114: R21.1 v2(73.3,67.75)
MIPI60_GP_C10: length 13.2
  BOTTOM w0.114: R42.2 v4(91.76,73.16) 90.09,73.16 89.43,73.82 87.34,73.82 83.84,69.25 83.84,68.45 J15.36
MIPI60_I2C_SCL: length 3.2
  BOTTOM w0.114: R41.2 89.07,68.74 TP1.1 88.65,69.14 87.65,69.14 J15.48
MIPI60_I2C_SDA: length 10.7
  BOTTOM w0.114: R47.2 89.53,69.48 89.35,69.66 87.98,69.66 J15.50 86.09,71.22 86.08,71.38 87.58,73.34 88.92,73.34 90.4,71.86 TP2.1
MIPI60_OVERRIDE_L: length 3.1
  TOP w0.109: v2(74.19,71.05) 73.13,70 D31.1
  BOTTOM w0.114: v2(74.19,71.05) 74.19,70.61 R3.2 R31.1
MIPI60_PCH_JTAG_TCLK: length 57.5
  TOP w0.089: 120.75,77.62 120.75,77.51 120.86,77.4 120.86,75.08 120.56,74.78 120.56,73.49 120.58,73.47 U1JSL.AL2
  TOP w0.109: 120.75,77.62 120.75,80.47 119.63,81.6 119.5,81.6 119.1,81.99 118.99,81.99 118.82,82.17 118.34,82.17 118.09,82.42 117.81,82.42 117.62,82.61 117.62,82.97 117.34,83.26 R283.1 117.34,84.01 117.18,84.16 116.93,84.16 v2(116.32,84.77)
  IN2 w0.097: v2(116.32,84.77) 115.93,85.16 111.4,85.16 108.38,82.14 95.2,82.14 93.68,80.62 88.03,80.62 85.01,77.6 79.37,77.6 78.71,76.94 v2(78.71,76.82)
  BOTTOM w0.114: R24.1 78.71,76.78 v2(78.71,76.82)
MIPI60_PCH_JTAG_TDI: length 69.8
  TOP w0.089: 122.17,77.46 122.12,77.41 122.12,73.15 121.9,72.93 121.9,72.48 U1JSL.AH3
  TOP w0.109: v2(121.2,84.21) 121.15,84.16 R282.2 121.15,82.09 122.17,81.06 122.17,77.46
  IN2 w0.097: v2(121.2,84.21) 121,84.21 119.29,82.51 111.55,82.51 109.2,80.16 105.91,80.16 103.57,77.83 102.28,77.83 101.19,76.74 87.41,76.74 85.63,74.97 83.97,74.97 83.46,74.46 82.64,74.46 75.1,66.92 73.23,66.92 72.92,66.62 v2(71.87,66.62)
  BOTTOM w0.114: R26.1 71.87,66.13 v2(71.87,66.62)
MIPI60_PCH_JTAG_TDO: length 84.2
  TOP w0.089: 121.7,77.55 121.7,75.1 121.76,75.04 121.76,73.64 121.62,73.5 121.62,73.13 121.71,73.04 121.71,72.69 121.43,72.42 U1JSL.AJ4
  TOP w0.109: v2(119.63,84.77) 119.63,84.42 119.88,84.16 R281.2 119.88,83.4 120.16,83.12 120.16,82.41 121.7,80.87 121.7,77.55
  IN2 w0.097: v2(68.45,64.5) 68.85,64.1 69.21,64.1 69.46,64.35 69.46,64.92 72.17,67.63 72.49,67.63 73.3,68.44 73.94,68.44 75.71,70.22 75.71,71.17 79.6,75.06 83.17,75.06 83.7,75.59 85.1,75.59 86.85,77.34 100.94,77.34 102.13,78.53 103.38,78.53 105.61,80.76 108.96,80.76 111.3,83.1 117.96,83.1 v2(119.63,84.77)
  BOTTOM w0.114: v2(68.45,64.5) 68.45,63.8 74.13,58.12 R27.1
MIPI60_PCH_JTAG_TMS: length 15.7
  TOP w0.089: 120.52,77.62 120.52,77.49 120.68,77.33 120.68,75.15 120.38,74.85 120.38,73.42 120.39,73.41 120.39,73.13 120.2,72.93 120.2,72.48 U1JSL.AM3
  TOP w0.109: R28.1 R280.2 116.19,83.53 116.54,83.18 117.07,83.18 117.37,82.89 117.37,82.36 117.54,82.18 117.99,82.18 118.3,81.87 118.56,81.87 v4(118.87,81.56) 119.2,81.23 119.67,81.23 120.52,80.38 120.52,77.62
MIPI60_PCH_JTAG_TRST_N: length 75.1
  TOP w0.089: 122.64,77.32 122.48,77.16 122.48,73.13 122.56,73.04 122.56,72.69 122.28,72.42 U1JSL.AG4
  TOP w0.109: 122.64,77.32 122.64,81.26 121.69,82.21 121.69,83.77 122.12,84.19 v2(122.12,84.77)
  IN4 w0.089: v2(122.12,84.77) 122.12,84.59 121.15,83.63 119.78,83.63 119.03,84.38 111.05,84.38 109.92,83.25 103.29,83.25 102.96,83.58 94.99,83.58 93.54,82.13 87.58,82.13 84.43,78.98 78.94,78.98 76.94,76.99 76.94,72.59 73.12,68.77 v2(71.78,68.77)
  BOTTOM w0.114: R29.1 72.28,68.77 v2(71.78,68.77)
MIPI60_PCH_JTAGX: length 70.8
  TOP w0.089: U1JSL.AL4 120.58,72.42 120.86,72.69 120.86,73.04 120.76,73.14 120.76,73.63 120.74,73.65 120.74,74.68 121.04,74.98 121.04,77.48 120.99,77.52 120.99,77.62
  TOP w0.109: 120.99,77.62 120.99,80.57 119.66,81.9 119.53,81.9 119.2,82.23 119.09,82.23 118.77,82.56 118.46,82.56 v4(118.15,82.87) 117.85,83.17 117.82,83.17 117.73,83.26 117.73,83.95 v2(116.91,84.77)
  IN2 w0.097: v2(70.25,66.84) 70.25,67.12 71.36,68.23 72.24,68.23 73.17,69.15 73.8,69.15 75.02,70.37 75.02,71.47 79.21,75.65 82.87,75.65 83.45,76.23 84.9,76.23 88.42,79.75 94,79.75 95.6,81.35 108.71,81.35 111.05,83.7 116.16,83.7 116.91,84.44 v2(116.91,84.77)
  BOTTOM w0.114: R25.1 70.25,66.48 v2(70.25,66.84)
MIPI60_POD_PRESENT1_L: length 3.4
  BOTTOM w0.114: J15.15 76.15,68.24 75.67,68.24 75.39,68.48 74.94,68.93 R33.1
MIPI60_POD_PRESENT2_L: length 3.6
  BOTTOM w0.114: J15.17 76.74,68.51 76.22,68.51 76.19,68.49 75.76,68.49 75.08,69.18 75.08,69.28 R31.2
MIPI60_PRDY_L: length 76.9
  TOP w0.109: U1JSL.Y3 125.33,72.5 125.33,72.95 125.83,73.46 125.83,74.56 126.21,74.94 126.21,76.06 126.93,76.78 126.93,79.06 127.43,79.56 127.43,80.87 126.92,81.39 126.92,82.46 125.19,84.19 v2(125.19,84.77)
  IN4 w0.089: v2(125.19,84.77) 123.97,83.55 123.17,83.55 122.3,82.68 118.93,82.68 118.2,83.4 111.42,83.4 110.28,82.26 102.93,82.26 102.56,82.62 95.19,82.62 93.93,81.37 88.11,81.37 83.13,76.39 80.28,76.39 77.51,73.62 77.51,72.35 74.31,69.15 74.31,68.29 v2(74.87,67.73)
  BOTTOM w0.114: J15.11 75.54,67.57 75.03,67.57 v2(74.87,67.73)
MIPI60_PREQ_L: length 92
  TOP w0.109: U1JSL.Y1 125.63,73.63 125.63,74.75 125.97,75.09 125.97,76.11 126.69,76.83 126.69,79.16 127.19,79.66 127.19,80.78 126.68,81.29 126.68,82.15 125.58,83.25 v4(125.11,83.25) 125.11,83.71 124.46,84.36 124.46,84.46 v2(124.17,84.75)
  IN4 w0.089: v2(124.17,84.75) 124.17,84.95 123.97,85.15 123.34,85.15 122.45,84.26 122.06,84.26 121.23,83.44 119.59,83.44 118.84,84.19 111.13,84.19 110,83.06 103.21,83.06 102.88,83.39 95.06,83.39 93.62,81.94 87.66,81.94 84.51,78.79 79.01,78.79 77.13,76.91 77.13,72.51 73.67,69.05 73.67,67.11 72.15,65.59 72.15,63.96 72.09,63.9 v2(72.09,63.53)
  BOTTOM w0.114: v2(72.09,63.53) 72.39,63.24 72.39,63.21 74.7,60.89 76.07,60.89 78.47,63.3 79.38,63.3 79.52,63.43 79.77,63.43 80.57,62.64 J15.10
MIPI60_PWR_BTN_L: length 6.2
  BOTTOM w0.114: R44.2 90.44,68.77 89.93,68.26 89.55,68.26 89.06,67.77 87.41,67.77 v4(87.11,67.48) 86.59,67.48 J15.40
MIPI60_RSMRST_L: length 2.7
  BOTTOM w0.114: J15.42 86.78,67.97 87.26,67.97 87.42,68.13 R45.2
MIPI60_TCK1: length 3.2
  BOTTOM w0.114: J15.51 82.03,75.18 80.31,75.18 R24.2
MIPI60_TCLK0: length 5.8
  BOTTOM w0.114: 75.3,65.13 74.44,65.85 74.19,65.85 73.51,65.17 v4(72.98,65.17) 72.05,65.17 R4.2 71.81,64.93 71.45,64.93 70.79,65.59 R25.2
MIPI60_TDI: length 3.7
  BOTTOM w0.114: J15.5 74.69,66.23 73.11,66.23 R5.2 R26.2
MIPI60_TDO: length 7.6
  BOTTOM w0.114: J15.4 78.89,62.16 78.78,62.27 78.47,62.27 75.34,59.15 75.34,58.55 R27.2 R6.2
MIPI60_TMS: length 78.2
  TOP w0.109: R17.2 R28.2 114.7,84.69 v2(114.78,84.77)
  IN2 w0.097: v2(114.78,84.77) 114.78,84.47 114.2,83.89 110.97,83.89 108.63,81.55 95.45,81.55 93.92,80.02 88.41,80.02 84.82,76.43 83.35,76.43 82.77,75.85 79.12,75.85 74.82,71.55 74.82,70.45 74.08,69.71 72.57,69.71 v2(72.17,69.31)
  BOTTOM w0.114: J15.2 80.26,60.24 80.26,59.31 77.78,56.83 v4(75.51,56.83) 75.08,56.83 67.96,63.95 67.96,67.12 70.25,69.4 72.08,69.4 v2(72.17,69.31)
MIPI60_TRST_L: length 4.7
  BOTTOM w0.114: R29.2 72.78,67.93 72.78,67.64 73.5,66.91 73.79,66.91 R21.2 74.95,67.12 75.3,67.12 J15.9
MIPI60_TRST_PD: length 13.2
  BOTTOM w0.114: R40.1 73.78,60.41 v4(73.78,59.96) 75.47,59.96 78.57,63.05 79.39,63.05 J15.8
MIPI60_VREF_DEBUG: length 6.1
  BOTTOM w0.114: R38.1 70.26,65.42 70.62,65.42 71.38,64.66 71.38,64.5 C18.2 71.27,64.2 v4(72.15,64.2) 74.5,64.2 74.63,64.32 J15.1
MPHY_RCOMP_DN: length 6.4
  TOP w0.109: v4(110.71,77.25) R34.2 110.71,76.4 112.03,75.08 112.03,74.4 113.05,73.39 113.05,73.19 113.21,73.03 113.21,72.73 112.92,72.45 U1JSL.BH4
MPHY_RCOMP_DP: length 6.9
  TOP w0.109: v4(110.46,78.52) 110.46,78.09 110.26,77.89 R34.1 110.26,76.4 111.75,74.91 111.75,74.39 112.76,73.38 112.76,73.01 U1JSL.BH2
PCH_OPIRCOMP: length 6.8
  TOP w0.109: v4(111.73,78.52) 111.42,78.21 111.14,78.21 111.02,78.09 111.02,77.69 111.38,77.32 R6E5.1 111.47,77.08 111.37,76.98 111.37,76.29 112.41,75.25 112.41,74.32 113.35,73.38 U1JSL.BG1
PCIE_4_PCH_RX_WLAN_TX_C_N: length 1.6
  BOTTOM w0.097: U4100.36 37.85,24.61 38.03,24.79 38.03,24.87 37.89,25.01 37.89,25.3 37.69,25.49 R91327.2
PCIE_4_PCH_RX_WLAN_TX_C_P: length 1.5
  BOTTOM w0.097: U4100.37 38.35,24.65 38.21,24.79 38.21,24.95 38.07,25.09 38.07,25.33 38.23,25.49 R91328.2
PCIE_4_PCH_RX_WLAN_TX_N: length 125
  TOP w0.089: U1JSL.BR2 109.52,72.55 109.21,72.11 v2(109.21,71.64)
  IN1 w0.097: v2(81.88,38.01) 81.69,37.82 81.17,37.82 81.07,37.91 81.07,38.58 80.85,38.8 79.45,38.8 77.47,36.82 72.1,36.82 70.85,38.06 70.85,38.46 68.82,40.49 63.27,40.49 61.42,38.63 55.07,38.63 54.74,38.31 54.74,37.93 54.56,37.74 54.37,37.74 54.2,37.92 54.2,38.33 53.89,38.63 53.44,38.63 53.12,38.31 53.12,37.44 53.02,37.34 52.77,37.34 52.65,37.46 52.65,38.35 52.36,38.63 50.71,38.63 46.52,34.45 45.62,34.45 43.02,31.85 43.02,29.36 41.95,28.28 38.94,28.28 37.81,27.15 37.81,26.82 v2(37.59,26.6)
  IN4 w0.097: v2(81.88,38.01) 81.69,37.82 81.57,37.82 81.49,37.9 81.49,38.21 82.22,38.94 82.22,41.9 81.98,42.14 81.51,42.14 81.41,42.23 81.41,42.59 81.51,42.68 81.97,42.68 82.22,42.93 82.22,47.23 81.09,48.36 81.09,54.91 86,59.81 86,63.26 87.95,65.21 90.79,65.21 92.26,63.74 95.16,63.74 95.79,64.37 99.38,64.37 100.22,65.21 100.22,67.37 100.98,68.13 100.98,71.91 102.16,73.09 103.39,73.09 103.73,73.43 107.66,73.43 108.88,72.21 109.61,72.21 109.71,72.11 109.71,71.65 109.59,71.54 109.31,71.54 v2(109.21,71.64)
  BOTTOM w0.097: R91327.1 37.8,25.94 37.95,26.09 37.95,26.31 37.65,26.6 v2(37.59,26.6)
PCIE_4_PCH_RX_WLAN_TX_P: length 125
  TOP w0.089: v1(110.38,71.56) 109.98,71.56 U1JSL.BR4
  IN1 w0.097: v2(81.88,37.42) 81.68,37.61 81.08,37.61 80.87,37.83 80.87,38.49 80.77,38.59 79.53,38.59 77.55,36.61 72.02,36.61 70.65,37.98 70.65,38.37 68.74,40.29 63.36,40.29 61.5,38.43 55.15,38.43 54.95,38.23 54.95,37.84 54.64,37.54 54.29,37.54 53.99,37.83 53.99,38.24 53.8,38.43 53.53,38.43 53.32,38.23 53.32,37.35 53.1,37.14 52.68,37.14 52.44,37.38 52.44,38.27 52.28,38.43 50.79,38.43 46.6,34.25 45.71,34.25 43.22,31.76 43.22,29.27 42.03,28.08 39.03,28.08 38.01,27.06 38.01,26.82 v2(38.23,26.6)
  IN4 w0.097: v1(110.38,71.56) 110.09,71.56 109.91,71.74 109.91,72.19 109.69,72.41 108.96,72.41 107.74,73.63 103.64,73.63 103.3,73.29 102.08,73.29 100.78,71.99 100.78,68.22 100.02,67.46 100.02,65.3 99.3,64.58 95.71,64.58 95.07,63.94 92.35,63.94 90.87,65.42 87.87,65.42 85.79,63.34 85.79,59.89 80.89,54.99 80.89,48.28 82.02,47.15 82.02,43.02 81.89,42.89 81.43,42.89 81.21,42.67 81.21,42.15 81.43,41.93 81.9,41.93 82.02,41.81 82.02,39.03 81.28,38.29 81.28,37.82 81.49,37.61 81.68,37.61 v2(81.88,37.42)
  BOTTOM w0.097: v2(38.23,26.6) 38.14,26.51 38.14,26.09 38.28,25.94 R91328.1
PCIE_4_PCH_TX_WLAN_RX_C_N: length 1.4
  BOTTOM w0.097: U4100.39 39.35,24.69 39.49,24.83 39.49,25.2 C109.2
PCIE_4_PCH_TX_WLAN_RX_C_P: length 1.4
  BOTTOM w0.097: C110.2 39.68,25.21 39.68,24.79 39.85,24.62 U4100.40
PCIE_4_PCH_TX_WLAN_RX_N: length 125.4
  TOP w0.089: U1JSL.BL8 111.47,70.5 v1(111.67,70.7)
  IN1 w0.097: v2(39.24,26.6) 39.46,26.82 39.46,27.04 40.06,27.65 42.4,27.65 47.51,32.76 47.51,34.44 50.81,37.74 51.8,37.74 52,37.54 52,37.1 52.4,36.7 54.66,36.7 54.97,37.01 54.97,37.3 55.19,37.52 56.85,37.52 57.09,37.77 61.83,37.77 63.94,39.87 68.58,39.87 70.19,38.26 70.19,37.88 71.86,36.21 78.25,36.21 78.43,36.39 78.43,36.89 78.74,37.2 79.98,37.2 v2(80.2,37.42)
  IN4 w0.097: v1(111.67,70.7) 111.46,70.49 111.35,70.49 111.28,70.56 111.28,71.31 111.42,71.45 111.79,71.45 111.99,71.65 111.99,72.22 111.67,72.55 110.41,72.55 109.93,73.03 109.21,73.03 108.01,74.23 104.8,74.23 103.69,75.34 102.13,75.34 100.91,74.12 100.91,73.05 100.17,72.31 100.17,68.5 99.44,67.77 98.98,67.77 96.81,65.59 95.8,65.59 94.77,64.56 92.84,64.56 91.38,66.03 87.61,66.03 85.16,63.57 85.16,60.12 80.27,55.23 80.27,47.94 81.34,46.87 81.34,46.52 81.25,46.43 80.86,46.43 80.59,46.16 80.59,45.72 80.85,45.45 81.24,45.45 81.34,45.35 81.34,44.99 81.24,44.89 80.83,44.89 80.59,44.65 80.59,44.29 80.85,44.03 81.24,44.03 81.34,43.93 81.34,43.66 81.25,43.57 80.87,43.57 80.59,43.29 80.59,41.25 80.91,40.92 81.2,40.92 81.34,40.78 81.34,39.22 80.66,38.54 80.66,37.38 80.5,37.22 80.39,37.22 v2(80.2,37.42)
  BOTTOM w0.097: v2(39.24,26.6) 39.49,26.36 39.49,26.09 39.34,25.94 C109.1
PCIE_4_PCH_TX_WLAN_RX_P: length 125.4
  TOP w0.089: v1(111.67,70.04) 111.67,69.72 111.58,69.63 111.45,69.63 U1JSL.BL9
  IN1 w0.097: v2(39.88,26.6) 39.66,26.82 39.66,26.96 40.15,27.44 42.48,27.44 47.71,32.67 47.71,34.36 50.89,37.54 51.71,37.54 51.8,37.46 51.8,37.01 52.31,36.5 54.74,36.5 55.17,36.93 55.17,37.21 55.28,37.32 56.93,37.32 57.18,37.56 61.92,37.56 64.02,39.67 68.5,39.67 69.99,38.17 69.99,37.79 71.78,36 78.34,36 78.64,36.3 78.64,36.81 78.82,36.99 80.02,36.99 v2(80.2,36.82)
  IN4 w0.097: v1(111.67,70.04) 111.42,70.29 111.26,70.29 111.08,70.47 111.08,71.4 111.33,71.65 111.71,71.65 111.79,71.74 111.79,72.14 111.59,72.34 110.33,72.34 109.84,72.83 109.12,72.83 107.92,74.03 104.71,74.03 103.61,75.13 102.21,75.13 101.11,74.03 101.11,72.96 100.37,72.22 100.37,68.41 99.52,67.56 99.07,67.56 96.89,65.39 95.89,65.39 94.86,64.36 92.76,64.36 91.3,65.82 87.7,65.82 85.36,63.49 85.36,60.03 80.47,55.14 80.47,48.03 81.54,46.96 81.54,46.43 81.34,46.23 80.94,46.23 80.79,46.07 80.79,45.8 80.94,45.65 81.32,45.65 81.54,45.44 81.54,44.91 81.32,44.69 80.91,44.69 80.79,44.57 80.79,44.37 80.93,44.23 81.32,44.23 81.54,44.01 81.54,43.58 81.33,43.37 80.96,43.37 80.79,43.2 80.79,41.33 81,41.13 81.28,41.13 81.54,40.86 81.54,39.13 80.86,38.45 80.86,37.29 80.59,37.01 80.39,37.01 v2(80.2,36.82)
  BOTTOM w0.097: v2(39.88,26.6) 39.68,26.4 39.68,26.05 39.78,25.94 C110.1
PCIE_4_WLAN_REFCLK_N: length 127
  TOP w0.089: v2(117.1,70.83) 117.03,70.9 116.8,70.9 116.65,70.75 U1JSL.AW8
  IN1 w0.097: v2(36.27,25.59) 36.48,25.79 36.48,27.17 38.27,28.97 41.62,28.97 42.33,29.68 42.33,32.14 45.34,35.14 46.02,35.14 50.21,39.33 56.07,39.33 56.68,39.95 61.32,39.95 62.55,41.18 69.1,41.18 71.54,38.74 71.54,38.36 72.08,37.82 75.38,37.82 75.46,37.9 77.56,37.9 79.86,40.19 80.57,40.19 v2(80.79,40.41)
  IN4 w0.097: v2(80.79,40.41) 80.6,40.22 80.48,40.22 80.1,40.59 80.1,47.35 79.77,47.68 79.77,55.42 81.15,56.8 81.15,57.22 84.68,60.74 84.68,63.77 87.42,66.51 91.95,66.51 92.08,66.64 92.94,66.64 93.31,66.27 94.82,66.27 94.96,66.41 96.92,66.41 99.28,68.77 99.28,71.32 99.21,71.4 99.21,72.16 100.11,73.07 100.11,74.05 101.94,75.88 103.85,75.88 105.01,74.72 108.2,74.72 109.4,73.52 110.12,73.52 110.57,73.07 114.28,73.07 116.17,71.19 116.75,71.19 v2(117.1,70.83)
  BOTTOM w0.097: U4100.33 36.35,24.83 36.51,24.99 36.51,25.35 v2(36.27,25.59)
PCIE_4_WLAN_REFCLK_P: length 127
  TOP w0.089: U1JSL.AW6 116.98,71.49 v2(117.1,71.49)
  IN1 w0.097: v2(36.88,25.59) 36.68,25.79 36.68,27.09 38.36,28.76 41.71,28.76 42.54,29.59 42.54,32.05 45.42,34.94 46.11,34.94 50.3,39.13 56.15,39.13 56.77,39.74 61.4,39.74 62.63,40.98 69.02,40.98 71.33,38.66 71.33,38.28 71.99,37.62 75.47,37.62 75.54,37.69 77.65,37.69 79.94,39.99 80.62,39.99 v2(80.79,39.82)
  IN4 w0.097: v2(80.79,39.82) 80.59,40.02 80.39,40.02 79.9,40.51 79.9,47.27 79.57,47.6 79.57,55.51 80.95,56.88 80.95,57.3 84.47,60.83 84.47,63.85 87.34,66.71 91.87,66.71 91.99,66.84 93.03,66.84 93.39,66.47 94.74,66.47 94.87,66.61 96.83,66.61 99.08,68.85 99.08,71.23 99,71.31 99,72.25 99.91,73.15 99.91,74.14 101.85,76.08 103.93,76.08 105.09,74.92 108.29,74.92 109.48,73.73 110.2,73.73 110.65,73.28 114.36,73.28 116.25,71.39 117,71.39 v2(117.1,71.49)
  BOTTOM w0.097: U4100.34 36.85,24.83 36.69,24.99 36.69,25.4 v2(36.88,25.59)
PCIE_SUB_REFCLK_N: length 1.8
  TOP w0.089: U1JSL.BA8 115.68,70.49 v2(115.29,70.78)
  BOTTOM w0.097: TP94.1 115.97,70.66 115.85,70.54 115.41,70.54 115.29,70.66 v2(115.29,70.78)
PCIE_SUB_REFCLK_P: length 1.8
  TOP w0.089: U1JSL.BA9 115.68,69.83 v2(115.29,70.12)
  BOTTOM w0.097: v2(115.29,70.12) 115.52,70.35 115.81,70.35 115.97,70.19 TP93.1
PEN_DET_ODL: length 211.4
  TOP w0.079: v1(153.56,22.72) U17.G4
  TOP w0.109: D32.1 90.45,68.64 v2(90.45,69.51)
  IN2 w0.097: v2(84.36,22.75) 85.74,21.37 90.79,21.37 93.76,18.4 101.99,18.4 102.67,19.08 104.5,19.08 105.57,20.15 108.5,20.15 109.02,20.68 115.65,20.68 117.93,18.4 119.17,18.4 120.9,16.67 143.16,16.67 145.61,19.12 145.61,19.88 146.74,21.01 147.5,21.01 147.78,21.29 151.15,21.29 152.24,22.39 153.23,22.39 v1(153.56,22.72)
  IN4 w0.079: v1(153.56,22.72) 153.56,22.67 153.84,22.39 155.75,22.39 155.97,22.16 155.97,21.78
  IN4 w0.089: v2(187.58,47.62) 187.58,47.52 187.08,47.03 187.08,46.13 186.49,45.54 186.49,42.76 186.9,42.36 186.9,36.65 188.41,35.14 188.41,29.29 185.05,25.92 184.04,25.92 182.64,24.52 182.64,21.4 180.32,19.07 173.55,19.07 171.71,20.91 170.03,20.91 169.9,20.78 169.9,19.08 167.86,17.05 163.29,17.05 161.29,19.05 160.36,19.05 159.4,20 159.4,20.52 158.97,20.95 156.61,20.95 155.97,21.59 155.97,21.78 ; v2(84.36,22.75) 82.27,24.84 77.52,24.84 75.57,26.8 75.57,34.02 77.78,36.23 77.78,46.34 76.76,47.37 76.76,51.72 75.65,52.83 75.65,56.04 76.18,56.58 76.9,56.58 79.42,59.09 79.42,61.93 87.15,69.66 90.3,69.66 v2(90.45,69.51)
  BOTTOM w0.114: v2(187.58,47.62) 186.92,48.28 C28021.2 R91349.1
PG_DRAM_OD: length 113.1
  TOP w0.079: U17.H8 v1(154.86,25.32)
  TOP w0.109: U22.10 183.79,41.47 183.98,41.66 v2(183.98,42.11) 183.99,42.12 R234.1 ; v2(165.6,76.1) 165.6,76.36 166.54,77.31 R453.1
  IN1 w0.079: 155.34,24.21 155.18,24.36 155.18,25.11 154.98,25.32 v1(154.86,25.32)
  IN1 w0.097: 155.34,24.21 156.37,24.21 156.72,23.86 158.51,23.86 159.35,23.01 163.79,23.01 165.05,21.75 172.42,21.75 174.03,23.35 174.64,23.35 177.7,26.41 181.09,26.41 186.34,31.66 186.34,33.23 v2(186.77,33.67)
  IN2 w0.097: v2(183.98,42.11) 183.47,42.11 182.14,43.45 182.14,50.61 181.63,51.12 181.63,54.67 179.94,56.36 177.48,56.36 177,56.85 177,57.78 175.71,59.07 v2(175.41,59.07) ; v2(165.6,76.1) 165.23,75.73 164.73,75.73 162,73.01 162,71.24 160.04,69.28 159.07,69.28 v2(158.9,69.45)
  BOTTOM w0.114: v2(158.9,69.45) 158.9,67.5 160.93,65.47 172.48,65.47 173.12,64.83 173.12,63.46 173.45,63.13 173.45,60.35 174.73,59.07 v2(175.41,59.07) 175.71,59.07 176.32,58.46 R27124.1 ; v2(186.77,33.67) 185.6,34.84 185.6,40.5 v4(184.42,41.67) v2(183.98,42.11)
