# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PG_PP1050_ST_S_OD: length 142.9
  TOP w0.079: U17.D3 151.67,21.74 151.33,21.4 151.07,21.4 150.92,21.25 150.92,20.99 150.64,20.71 150.39,20.71 150.26,20.59 150.26,20.25 149.9,19.89
  TOP w0.109: U27.C1 67.53,66.56 68.47,67.5 TP55.1 69.49,67.88 v2(70.38,68.77) ; 149.9,19.89 149.24,19.24 v1(149.24,18.5)
  IN4 w0.089: v2(70.38,68.77) 70.38,68.72 71.25,67.84 71.25,65.9 71.51,65.63 71.51,63.14 72.28,62.37 72.28,54.69 75.73,51.24 75.73,46.94 77.01,45.66 77.01,36.97 74.73,34.7 74.73,28.28 72.89,26.44 72.89,24.45 74.4,22.93 76.62,22.93 77.51,22.05 83.3,22.05 84.77,20.59 90.01,20.59 91.99,18.6 91.99,16.41 92.44,15.96 95.61,15.96 95.95,15.62 102.32,15.62 102.72,16.03 107.51,16.03 108.11,16.62 109.66,16.62 111.4,14.88 143.55,14.88 143.89,15.23 146.7,15.23 148.89,17.41 148.89,18.1 149.24,18.45 v1(149.24,18.5)
PG_PP1800_A_OD: length 95.5
  TOP w0.109: U21.19 50.11,61.84 51.36,63.09 51.36,64.18 51.71,64.53 51.71,65.05 53.04,66.38 v4(53.04,67.54) 53.04,68.46 D27.2 v2(51.83,68.9) ; v2(74.05,28.8) 73.96,28.71 R273.2 73.58,27.37 72.63,27.37 72.03,26.77 72.03,26.6 72.21,26.43 U32.1
  IN4 w0.089: v2(51.83,68.9) 43.23,68.9 41.45,67.12 41.29,67.12 40.77,66.59 40.77,65.45 37.42,62.1 37.42,60.51 36.52,59.61 36.52,58.35 35.68,57.52 35.68,56.63 41.76,50.54 44.26,50.54 51.42,43.38 62.27,43.38 62.67,42.99 70.41,42.99 72.77,40.63 72.77,38.8 73.66,37.91 73.66,29.2 v2(74.05,28.8)
PG_PP1800_DRAM_U: length 11.9
  TOP w0.109: R467.2 184.72,44.96 Q37.3 185.37,44.48 185.9,43.95 v2(185.9,43.86) ; R239.2 185.51,39.31 185.33,39.14 R465.1 185.25,38.83 R295.2 183.97,38.83 v2(183.8,38.66) 184.56,37.89 D18.2
  IN2 w0.102: v2(183.8,38.66) 185.57,40.42 185.57,43.53 v2(185.9,43.86)
PG_PP3300_G_OD: length 54.1
  TOP w0.203: v2(41.01,44.25) 41.01,44.09 40.76,43.84 U30.7
  IN4 w0.089: v2(61.13,39.1) 60.46,38.43 50.95,38.43 44.73,44.65 41.36,44.65 41.01,44.3 v2(41.01,44.25)
  BOTTOM w0.114: v2(41.01,44.25) 41.01,44.3 41.21,44.5 R260.2
  BOTTOM w0.117: v2(61.13,39.1) 61.56,38.67 70.59,38.67 71.05,39.13 72.44,39.13 73.29,38.28 77.29,38.28 80.2,41.18 83.96,41.18 85.08,42.3 87.04,42.3 87.57,42.83 D22.1
PG_PP5000_U_OD: length 123.9
  TOP w0.079: 148.81,25.51 149.55,25.51 149.62,25.44 149.73,25.44 149.88,25.29 150.34,25.29 U17.B8
  TOP w0.109: v1(141.06,23.59) 141.95,24.49 141.95,24.57 142.9,25.51 148.81,25.51
  TOP w0.203: R261.2 42.76,35.77 42.44,35.44 v2(42.44,35.42) 42.44,35.22 42.16,34.94 41.62,34.94 41.45,34.76 U31.7
  IN2 w0.097: v2(42.44,35.42) 42.46,35.42 42.89,34.99 49.54,34.99 52.5,32.02 60.83,32.02 71.63,21.22 81.91,21.22 84.17,23.48 85.53,23.48 87.25,21.76 91.01,21.76 93.21,19.56 104.28,19.56 105.35,20.63 107.19,20.63 107.84,21.27 116.05,21.27 117.34,19.98 124.48,19.98 124.97,19.49 131.02,19.49 131.41,19.88 133.89,19.88 134.38,20.38 134.38,21.27 134.98,21.87 136.96,21.87 138.31,23.22 140.69,23.22 v1(141.06,23.59)
PG_V1P05_OD: length 2.6
  TOP w0.254: v2(58.31,39.1) 58.44,39.1 59.02,38.52 U33.7
  BOTTOM w0.203: R291.1 R13.2 58.18,39.23 v2(58.31,39.1)
PG_VCCIN_AUX_OD: length 49.1
  TOP w0.109: v2(60.09,32.48) R240.1 ; U21.4 47.95,58.17 47.64,58.48 R230.1 47.26,58.46 47.26,57.59 v2(46.88,57.21)
  IN1 w0.097: v2(41.36,56.41) 41.79,56.83 46.5,56.83 v2(46.88,57.21)
  IN2 w0.097: v2(42.58,45.05) 43.37,44.25 48.69,44.25 49.69,43.26 49.69,36.12 52.82,32.99 59.59,32.99 v2(60.09,32.48)
  BOTTOM w0.114: v2(42.58,45.05) 42.58,45.37 43.15,45.93 43.15,48.22 42.9,48.46 42.9,54.88 v2(41.36,56.41)
PG_VCCIO_EXT_OD: length 123.9
  TOP w0.079: U17.G8 v1(154.21,25.32)
  TOP w0.109: R456.2 164.11,78.57 v2(164.11,78.09) 164.07,78.09 163.96,77.98 U38.2
  IN1 w0.079: 154.83,24.01 154.54,24.3 154.54,24.99 v1(154.21,25.32)
  IN1 w0.097: 154.83,24.01 156.28,24.01 156.63,23.66 158.41,23.66 159.26,22.81 163.71,22.81 164.97,21.55 172.53,21.55 174.13,23.15 174.74,23.15 177.79,26.2 181.17,26.2 188.34,33.37 188.34,41.06 188.77,41.48 188.77,55.44 v2(188.57,55.64) 188.57,56.24 171.85,72.95 171.85,75.12 170.86,76.1 170.63,76.1 v2(170.02,76.72)
  IN2 w0.097: v2(164.11,78.09) 165.07,77.13 169.61,77.13 v2(170.02,76.72)
  BOTTOM w0.114: R110.1 175.41,55.3 175.41,54.18 v4(176.24,53.34) 176.24,50.9 178.56,48.58 182.01,48.58 182.26,48.83 182.26,49.87 182.69,50.3 185.15,50.3 188.07,53.22 188.07,55.14 v2(188.57,55.64)
PG_VNN_OD: length 3.9
  TOP w0.254: v2(59.02,34.1) U33.14
  BOTTOM w0.203: R290.1 57.69,36 57.79,36.1 R292.1 58.08,35.36 59.02,34.42 v2(59.02,34.1)
PLT_RST_L: length 190.6
  TOP w0.079: v1(162.59,19.63) 162.97,19.63 163.01,19.6 U13.A2
  TOP w0.089: 100.22,55.64 100.37,55.78 100.8,55.78 100.89,55.73 100.99,55.61 100.99,55.55 101.29,55.25 U1JSL.CM41
  TOP w0.109: R11107.1 v2(97.75,54.76) 98.63,55.64 100.22,55.64
  IN1 w0.097: v1(162.59,19.63) 162.59,19.77 162.23,20.13 160.67,20.13 158.01,17.46 155.7,17.46 154,15.76 152.4,15.76 151.34,14.71 122.37,14.71 119.47,17.61 116.91,17.61 112.13,22.38 99.69,22.38 99.24,22.84 95.77,22.84 93.91,24.69 89.55,24.69 89.41,24.84 v2(89.31,24.84)
  IN2 w0.097: v2(97.75,54.76) 97.73,54.76 96.79,53.83 96.79,52.64 96.92,52.51 96.92,49.34 96.21,48.63 94.33,48.63 93.69,49.26 89.91,49.26 89.68,49.04 87.26,49.04 83.07,44.84 83.07,31.39 89.31,25.15 v2(89.31,24.84)
  BOTTOM w0.114: v2(89.31,24.84) 88.32,23.85 81.71,23.85 81.19,24.37 77.33,24.37 74.65,27.06 73.26,27.06 70.68,29.64 70.68,30.59 70.54,30.72 58.36,30.72 56.7,32.39 49.7,32.39 45.07,27.76 37.94,27.76 37.35,28.35 U16.3
PP600_DRAM_U: length 41.5
  TOP w0.254: R4705.2 109.09,35.48 v1(107.24,35.48) U4701.B5 ; U4301.U3 155.4,40.04 ; U4601.F3 v1(116.55,38.19) ; U4401.AA8 134.11,28.52 v1(134.11,29.12) U4401.W8 ; R4305.2 144.84,41.78 v1(144.97,41.66) U4301.B5 ; U4301.D8 146.26,43.28 145.69,43.28 U4301.B8 144.81,43.13 v1(144.29,43.13) 144.18,43.24 R4306.2 ; U4601.U10 v1(122.13,30.45) ; U4701.W5 v1(95.53,35.54) ; U4701.B8 v1(107.24,33.94) 107.43,34.12 R4706.2 ; U4601.W5 v1(119.22,29.08) 118.96,28.41 U4601.AA5 ; U4401.W5 132.5,29.03 v1(132.5,28.45) U4401.AA5 ; U4701.W8 v1(95.55,33.91) 94.98,33.91 U4701.AA8 ; U4701.AA5 94.66,35.83 94.66,34.94 v1(94.63,34.91) ; U4701.D12 105.94,29.89 ; U4301.W1 156.7,37.64 ; U4301.W5 156.78,41.64 v1(157.35,41.64) U4301.AA5 ; U4301.AA3 v1(157.35,39.24) ; U4601.B3 v1(116.55,40.79) ; U4601.AA8 120.56,28.52 v1(120.56,29.12) U4601.W8 ; v1(122.16,40.14) U4601.B10 ; U4301.AA8 v1(157.35,43.24) 156.78,43.24 U4301.W8 ; U4301.D5 v1(146.27,41.66) ; U4301.U10 155.4,45.64 ; U4701.D5 v1(105.94,35.48) ; U4601.U3 117.36,30.4 ; U4701.D8 v1(105.94,33.94)
  IN3 w0.254: 133.15,28.16 132.86,28.45 v1(132.5,28.45) ; 133.15,28.16 v1(133.15,26.35) ; 133.15,28.16 v1(134.11,29.12) ; v1(120.56,29.12) 120.51,29.08 v1(119.22,29.08) 119.95,28.35 119.95,27.32 120.29,26.99 v1(120.29,26.6)
  IN3 w0.508: v1(157.35,43.24) v1(157.35,41.64)
  vias: v1(96.16,37.1) v1(120.49,38.89) v1(144.29,37.48) v2(177.58,35.99) v2(178.27,35.99) v4(112.16,26.99) v4(160.67,36.38) v4(160.67,35.75) v4(161.82,35.39)
PP600_DRAM_U_R:
  vias: v4(179.13,38.51)
PP850_VCCLDOSTD: length 1.9
  TOP w0.254: v2(101.86,51.74) 101.82,51.71 U1JSL.CN49
  BOTTOM w0.114: v2(101.86,51.74) 101.97,51.62 v4(101.97,51.12)
  BOTTOM w0.254: v2(101.86,51.74) 101.32,51.74 C491.1
PP1050_OUT_PCH: length 66.6
  IN2 w0.762: v3(69.49,66.71) 69.49,66.23 68.72,65.47 67.95,65.47 67.45,65.96 67.45,67.83 68.61,68.99 68.61,70.2 72.78,74.37 72.78,75.84 v3(74.66,77.73)
  BOTTOM w0.254: R38.2 69.49,65.97 v3(69.49,66.71) 69.49,67.24 70,67.75 71.24,67.75 R37.2
  BOTTOM w0.762: 114.78,76.77 112.83,76.77 107.5,82.1 91.84,82.1 91.03,81.29 88.06,81.29 85.35,78.59 76.83,78.59 75.68,77.44 74.95,77.44 v3(74.66,77.73)
  vias: v2(114.95,75.71) v2(115.54,75.71) v4(69.42,65.99) v4(115.56,76.67)
PP1050_OUT_PLL: length 0.9
  TOP w0.25: U1JSL.AY4 U1JSL.BB4
PP1050_ST_CT: length 1.6
  TOP w0.109: U27.C2 67.53,63.76 TP10.1
PP1050_ST_S: length 186.5
  TOP w0.203: v2(118.38,77.86) 118.73,77.51 R8604.1 ; R3F3.1 125.71,79.18 R8602.1
  TOP w0.254: R8607.1 112.64,84.44 112.82,84.62 v2(112.82,84.77)
  TOP w0.381: R318.1 R2F1.1 179.29,48.36 178.78,47.85 178.78,47.08 179.7,46.16 181.96,46.16 184.09,48.29 185.17,48.29 185.4,48.51 v2(186.49,48.51) ; R8602.1 125.88,79.45 v2(125.88,80) ; R3F4.1 v2(123.84,80)
  IN2 w0.508: v2(116.73,77.86) v2(118.38,77.86) 120.49,77.86 122.62,80 v2(123.84,80) v2(125.88,80) 126.74,80 127.27,80.53 127.27,82.1 127.78,82.61 130.32,82.61 131.08,81.85 136.54,81.85 137.5,82.8 143.44,82.8 144.37,83.73 166.33,83.73 169.55,80.51 176.63,80.51 186.78,70.36 186.78,60.68 187.51,59.96 187.51,51.28 186.49,50.27 v2(186.49,48.51)
  IN2 w0.762: v3(75.4,78.48) 75.74,78.13 75.74,77.37 73.64,75.27 73.64,74.01 69.5,69.87 69.5,68.23 68.47,67.2 v3(68.47,66.74)
  BOTTOM w0.203: v2(112.82,84.77) 112.82,84.11 113.3,83.63 115.33,83.63 116.1,82.87 116.1,79.03 116.5,78.62
  BOTTOM w0.762: v3(75.4,78.48) 76.41,79.49 84.88,79.49 87.58,82.18 90.66,82.18 91.47,82.99 107.87,82.99 112.24,78.62 116.5,78.62 116.53,78.6
  vias: v2(116.15,77.86)
PP1050_STG_S0: length 37.1
  TOP w0.203: 111.51,82.12 115.47,82.12 v4(116.35,81.24) 116.35,79.56 116.83,79.08 C3423.1 117.21,78.42 117.21,77.64 117.01,77.44 117.01,74.15 116.75,73.9 U1JSL.AW1 U1JSL.AW3 ; R281.1 119.43,83.42 119.8,83.05 R251.1
  TOP w0.254: 119.14,85 119.14,84.36 119.43,84.08 R281.1 ; 119.14,85 119.4,85.25 121.05,85.25 ; 119.14,85 118.89,85.25 115.23,85.25 ; 115.23,85.25 115.26,85.23 115.26,84.47 115.46,84.26 R280.1 ; 115.23,85.25 111.31,85.25 110.95,84.9 110.95,82.68 111.51,82.12 ; 121.05,85.25 121.05,84.75 120.7,84.39 R282.1 ; 121.05,85.25 122.34,85.25 122.72,84.88 R8603.1 R8609.1
PP1050_V1P05EXT: length 14.7
  TOP w0.254: U1JSL.BP18 v2(109.71,65.27) U1JSL.BT18 v2(108.94,65.28) U1JSL.BU18 v2(108.19,65.3) U1JSL.BW18 v2(107.41,65.28) U1JSL.CA18
  BOTTOM w0.203: R293.1 61.3,35.51 61.46,35.34 C28003.1 C28002.2 62.86,34.54 63.46,33.95 67.84,33.95 68.34,34.45 v4(68.34,36.13)
  vias: v4(68.34,38.03) v4(68.34,37.4) v4(68.34,36.76) v4(70.79,59.21) v4(70.79,58.56) v4(71.43,59.21) v4(71.43,58.56)
PP1050_VCCIO_EXT: length 86.7
  TOP w0.203: R36.1 124.32,83.08 123.51,82.27 v2(123.51,81.98) ; v2(128.52,78.37) 128.39,78.24 R405.1
  TOP w0.254: v2(118,67.63) 117.57,67.2 U1JSL.AU15 ; v2(120.42,67.58) 120.03,67.2 U1JSL.AM15 ; v2(117.1,67.58) 117.1,67.55 116.75,67.2 U1JSL.AW15 ; U1JSL.AJ15 121.17,67.2 v2(121.6,67.63) ; U1JSL.AR15 118.88,67.2 v2(119.23,67.55)
  IN2 w0.508: v2(89.2,74.99) 89.2,75.25 89.68,75.73 91.36,75.73 92.23,74.86 100.9,74.86 102.29,76.25 104.37,76.25 105.66,77.53 112.04,77.53 112.44,77.13 123.9,77.13 125.15,78.37 v2(128.52,78.37)
  BOTTOM w0.254: J15.12 79.49,64.24 79.49,64.81 79.77,65.09 79.9,65.09 83.53,68.71 83.53,69.42 87.41,74.48 88.94,74.48 89.2,74.74 v2(89.2,74.99) 89.2,75.37 87.27,77.3 79.96,77.3 79.8,77.14 ; 79.8,77.14 79.64,77.3 78.49,77.3 78.21,77.03 78.21,76.2 R412.1 R409.1 R408.1 R407.1 76.63,72.55 76.63,72.17 R411.1 ; 79.8,77.14 79.8,76.77 R32.1
  vias: v4(122.47,77.96) v4(132.99,80.83) v4(132.99,80.2) v4(133.62,80.83) v4(133.62,80.2) v4(134.26,80.83) v4(134.26,80.2) v4(134.89,80.83) v4(134.89,80.2) v4(141.88,76.13) v4(141.88,75.5) v4(142.51,76.13) v4(142.51,75.5) v4(143.15,76.13) v4(143.15,75.5) v4(143.78,76.13) v4(143.78,75.5) v4(144.42,76.13) v4(144.42,75.5) v4(145.06,77.64)
PP1050_VCCSTG_OUT: length 2.5
  TOP w0.254: U1JSL.BE34 113.71,58.55 113.34,58.55 U1JSL.BG34 112.95,58.55 112.58,58.55 U1JSL.BJ34 112.18,58.55 111.82,58.55 U1JSL.BK34
PP1100_DRAM_U: length 52.3
  TOP w0.254: U1JSL.V34 v2(125.72,58.08) U1JSL.Y34 v2(124.96,58.06) ; U1JSL.V34 v2(126.48,58.79) U1JSL.U34 ; U1JSL.V34 v2(126.48,58.06) ; U1JSL.AK34 v2(120.39,58.06) ; v2(120.39,58.06) U1JSL.AM36 ; v2(120.39,58.06) U1JSL.AK36 ; U1JSL.AY34 v2(116.59,58.06) ; v2(116.59,58.06) U1JSL.AY36 U1JSL.BB36 v1(115.06,57.38) U1JSL.BD36 ; v2(116.59,58.06) U1JSL.AW34 v2(117.34,58.06) ; U1JSL.AH34 v2(121.15,58.06) ; v2(121.15,58.06) U1JSL.AH36 U1JSL.AG36 ; v2(121.15,58.06) U1JSL.AK36 ; U4701.AB9 v1(93.52,33.01) ; v2(117.34,58.06) U1JSL.AU34 v2(118.1,58.06) ; v2(117.34,58.06) U1JSL.AW36 v1(117.43,57.3) U1JSL.AV38 ; U1JSL.BP36 v1(110.48,57.38) U1JSL.BM36 v1(111.24,57.38) U1JSL.BK36 ; v1(112,57.38) U1JSL.BJ36 ; v1(112,57.38) U1JSL.BK36 ; v1(112,57.38) U1JSL.BK38 ; U1JSL.BJ36 v2(112.76,58.1) U1JSL.BG36 v2(113.52,58.1) ; U1JSL.BJ36 v2(112,58.1) ; v2(119.62,58.06) U1JSL.AM36 ; v2(119.62,58.06) U1JSL.AP36 v2(118.86,58.06) U1JSL.AR34 v2(118.1,58.06) ; v2(119.62,58.06) U1JSL.AM34 ; U1JSL.AM36 v1(120.34,57.39) ; v2(124.96,58.06) U1JSL.AB36 U1JSL.AC36 v2(123.43,58.06) ; v2(124.96,58.06) U1JSL.AB34 U1JSL.AC34 v2(123.43,58.06) ; U1JSL.AR36 v2(118.1,58.06) ; v2(118.1,58.06) U1JSL.AU36 ; U1JSL.BK36 v2(111.24,58.1) ; U1JSL.P38 v1(128.3,56.61) ; U4601.A9 121.3,41.58 121.3,43.44 ; U4401.F5 v1(132.54,38.19) ; v2(126.48,58.06) U1JSL.V36 v1(125.67,57.32) ; v2(126.48,58.06) U1JSL.U36 ; U1JSL.AE34 v2(123.43,58.06) ; v2(123.43,58.06) U1JSL.AE36 v2(122.67,58.06) U1JSL.AG36 ; v1(125.67,57.32) U1JSL.Y38 ; v1(125.67,57.32) U1JSL.Y36 ; U4401.R5 v1(132.51,31.7) ; U1JSL.AG36 U1JSL.AF38 ; U4601.F8 v1(120.56,37.59) ; U4401.U8 v1(134.11,31.05) ; U1JSL.AK36 v1(120.34,57.39) ; v1(120.34,57.39) U1JSL.AM38 ; U1JSL.BD36 U1JSL.BD38 U1JSL.BE36 v2(114.29,58.1) U1JSL.BD36 ; U4601.A4 v1(117.85,41.68) ; v1(131.71,40.81) U4401.A4 ; U4401.A9 v1(134.91,41.46) ; U4701.R5 v1(98.79,35.51) ; U4401.AB4 v1(131.96,26.92)
  IN5 w0.508: v1(117.85,41.68) 118.24,41.68 118.76,41.16 118.76,39.64 119.72,38.68 119.72,38.1 120.22,37.59 v1(120.56,37.59)
  vias: v1(96.95,35.45) v1(134.96,27.1) v2(117.34,58.79) v2(118.1,58.79) v4(97.55,34.73) v4(98.19,34.73) v4(98.82,34.73) v4(109.87,42.61) v4(153.84,53.66) v4(153.84,53.02) v4(153.84,52.39) v4(154.48,53.66) v4(154.48,53.02) v4(154.48,52.39) v4(155.11,53.66) v4(155.11,53.02) v4(155.11,52.39) v4(155.75,53.66) v4(155.75,53.02) v4(155.75,52.39)
PP1100_DRAM_U_R: length 48.9
  TOP w0.203: v2(182.39,36.99) 182.43,36.96 182.85,36.96 C380.1 R445.1 182.87,38.1 182.63,38.34 U22.5 ; U22.19 179.62,40.27 179.42,40.07 178.73,40.07
  TOP w0.508: 178.73,40.07 178.73,40.07 177.75,40.07 C379.1 177.71,40 178.31,39.39 v2(178.52,39.39)
  IN4 w0.254: v2(182.39,36.99) 180.22,36.99 178.51,35.29 175.84,35.29 173.85,37.27 165.25,37.27 163.85,38.67 v2(163.85,45.4)
  BOTTOM w0.508: v2(178.52,39.39) 176.76,39.39 174.64,37.27 164.74,37.27 v2(164.48,37.02)
  vias: v4(162.8,37.95)
PP1100_PLLOC_CT: length 2.9
  TOP w0.109: 89.28,37.17 TP9.1
  TOP w0.117: 89.28,37.17 87.84,35.74 U26.C2
PP1100_PLLOC_S0: length 1.7
  TOP w0.305: U1JSL.BV38 v2(108.47,56.61) U1JSL.BV39 v2(108.47,55.95)
  vias: v2(85.66,34.38) v2(85.66,33.71) v4(86.63,33.95)
PP1240_VCCDPHY: length 1.7
  TOP w0.254: U1JSL.CM48 v2(101.36,52.37)
  BOTTOM w0.254: v2(101.36,52.37) 100.64,52.37 C489.1
PP1800_A: length 447
  TOP w0.203: R91363.1 19.25,9.41 v2(19.37,9.28) ; v2(25.16,38.67) 25.04,38.8 R84.1 ; R187.1 22.32,9.59 v2(21.94,9.97) ; v2(22.04,34.2) 22.24,34 R86.1 ; R180.1 21.39,17.24 21.1,16.95 v2(20.85,16.95) ; R132.1 R130.1 153.83,30.94 v2(154.2,31.3) ; v2(94.81,63.23) 94.51,62.93 94,62.93 93.75,63.18 93.75,63.56 93.62,63.69 93.62,64.3 94.25,64.93 94.25,64.94 v2(94.23,64.96) 93.93,64.96 93.44,65.45 92.41,65.45 91.65,66.21 91.65,68.19 91.33,68.52 91.33,69.12 91.53,69.33 91.53,69.71 91.21,70.04 91.21,70.34 90.85,70.7 90.85,71.17 91.6,71.92 93.05,71.92 93.11,71.87 93.85,71.87 93.87,71.89 95.46,71.89 R324.1 R316.1
  TOP w0.254: R82.1 21.83,32.73 v2(21.61,32.95) ; C386.1 183.11,35
  TOP w0.508: R91338.1 42.98,67.84 v2(43.45,67.37)
  IN1 w0.254: v2(96.18,62.37) 96.18,62.54 95.49,63.23 v2(94.81,63.23)
  IN1 w0.508: v2(21.61,32.95) 21.61,30.07 20.18,28.64 18.99,28.64 16.74,26.39 16.74,26.19 15.21,24.65 15.21,18.6 17.19,16.62 20.52,16.62 v2(20.85,16.95) 21.94,15.86 v2(21.94,9.97) 19.83,9.97 19.37,9.51 v2(19.37,9.28) ; v2(183.75,35.04) 182.4,35.04 181.83,34.47 164.47,34.47 161.83,31.83 155.94,31.83 155.42,31.3 v2(154.2,31.3) ; v2(175.29,76.84) v2(175.29,76.15) 175.82,75.63 178.07,75.63 179.16,74.54 179.16,67.91 188.65,58.42 v2(189.26,58.42)
  IN2 w0.508: v2(183.75,35.04) 184.87,36.16 184.87,38.02 186.64,39.8 186.64,40.25 188.68,42.28 188.68,54.8 189.26,55.39 v2(189.26,58.42) ; v2(66.17,69.81) 65.44,70.55 64.43,70.55 64.15,70.27 64.15,69.63 63.67,69.15 62.43,69.15 61.54,70.04 51.2,70.04 48.81,67.65 43.73,67.65 v2(43.45,67.37) 42.44,67.37 42.06,66.99 39.6,66.99 39.41,66.8 33.77,66.8 33.39,66.42 26.8,66.42 23.84,63.46 22.01,63.46 19.58,61.02 19.58,57.81 v2(18.56,56.79) 17.04,55.27 17.04,48.32 v2(16.78,48.07) ; v2(79.77,56.31) 79.85,56.38 v4(85.84,56.38)
  IN2 w1.016: v4(109.62,84.47) v4(108.72,84.47) 107.34,83.08 94.95,83.08 93.16,81.3 87.56,81.3 84.58,78.32 78.21,78.32 74.75,74.86 74.75,73.57 72.57,71.4
  IN4 w0.508: v2(43.45,67.37) 43.83,66.99 43.83,62.67 40.4,59.24 v2(40.4,59.02) ; v4(85.84,56.38) 89.42,56.38 93.36,60.32 93.36,61.05 93.97,61.66 95.73,61.66 96.18,62.11 v2(96.18,62.37)
  IN4 w1.016: 175.89,77.44 177.67,79.22 188.47,79.22 v4(189.26,80.01) v4(189.26,80.91) ; 175.49,77.14 166.31,86.32 111.47,86.32 v4(109.62,84.47) v4(108.72,84.47)
  BOTTOM w0.203: R1030.1 94.92,63.29 94.86,63.23 v2(94.81,63.23) ; R329.1 R330.1 98.78,61.99 97.62,61.99 97.21,61.58 96.75,61.58 96.57,61.76 R328.1 96.51,61.99 96.18,62.33 96.18,62.36 v2(96.18,62.37) 96.18,62.38 96.18,62.41 96.51,62.75 R327.1 ; R1029.1 95.29,65.31 95.17,65.44 94.55,65.44 94.25,65.14 94.25,64.99 v2(94.23,64.96)
  BOTTOM w0.254: 167.72,76.07 167.53,75.88 166.69,75.88 165.98,75.17 165.98,72.99 167.14,71.83 U15.8 ; v2(40.4,59.02) 40.4,59.75 40.76,60.1 C28010.1 41.24,60.1 41.75,60.62 J23.1 ; U15.5 169.3,70.92 169.28,70.9 C92.1 C89.1 169.85,70.06 170.1,69.8 172,69.8 173.25,71.05 173.25,73.9 175.29,75.95 v2(175.29,76.15)
  BOTTOM w0.508: 167.72,76.07 v4(169.02,77.37) 174.76,77.37 v2(175.29,76.84) v2(175.29,76.15) ; v2(18.56,56.79) 18.72,56.63 22.72,56.63 23.23,57.15 27.45,57.15 31.31,53.29 31.31,50.32 30.64,49.65 30.64,49.26 30.27,48.89 30.27,48.41 26.69,44.83 26.69,40.07 25.29,38.67 v2(25.16,38.67) 24.91,38.42 24.91,36.51 22.6,34.2 v2(22.04,34.2) 22.04,33.39 v2(21.61,32.95)
  vias: v2(76.12,55.72) v2(76.12,55.11) v4(71.55,70.6) v4(71.98,71.1) v4(80.52,52.89)
PP1800_A_R: length 13.9
  TOP w0.203: R277.1 C268.1 75.72,23 v2(76.65,23.94)
  IN2 w0.508: v2(76.14,33.43) 75.62,33.43 75.36,33.18 75.36,25.23 v2(76.65,23.94)
  vias: v4(75.61,33.08)
PP1800_AGSH_CT: length 1.7
  TOP w0.109: TP8.1 81.37,57.29 81.73,57.64 U24.C2
PP1800_AGSH_S0: length 83.2
  TOP w0.279: U1JSL.AV4 U1JSL.AV2
  TOP w0.304: v2(117.51,80.71) 117.63,80.59 C3406.2 117.63,79.19 117.59,79.15 117.59,77.54 117.36,77.31 117.36,74.02 117.18,73.84 U1JSL.AV2
  TOP w0.508: v2(83.66,62.32) 84.35,61.63 v4(84.35,59.49) 84.35,58.02 R247.2
  IN1 w0.508: v2(83.66,62.32) 82.21,63.77 v2(79.2,63.77)
  IN2 w0.508: v2(117.51,80.71) 117.51,81.07 116.6,81.98 112.29,81.98 108.86,78.55 105.77,78.55 104.17,76.94 101.99,76.94 101.39,76.34 87.74,76.34 85.95,74.55 84.12,74.55 83.61,74.04 82.79,74.04 75.27,66.52 74.27,66.52 v2(73.42,65.67)
  IN4 w0.508: v2(73.42,65.67) 73.08,65.33 73.08,61.17 73.6,60.65 76.61,60.65 79.2,63.24 v2(79.2,63.77)
PP1800_CLKLDO: length 1.5
  TOP w0.254: R8.1 92.39,75.58 92.73,75.25 92.73,75.12
  TOP w0.305: U1JSL.CN3 101.31,72.8 U1JSL.CN1
  vias: v4(95.98,75.2)
PP1800_DRAM_U: length 105
  TOP w0.254: v1(97.5,39.53) 97.48,39.5 U4701.U1 ; U4401.T9 v1(135.71,31.05) ; U4301.F12 v1(147.61,47.26) ; v1(98.16,37.15) 98.16,37.05 U4701.T4 ; U4401.U12 138.11,30.4 v1(138.11,30.4) ; U4601.F1 v1(114.94,38.19) ; U4601.U12 v1(124.56,30.4) ; U4601.F12 124.56,38.19 v1(124.57,38.19) ; v1(121.36,36.98) 121.36,36.99 121.7,37.23 U4601.G9 ; U4401.F12 138.11,38.17 v1(138.14,38.19) ; U4401.F1 128.52,38.17 v1(128.52,38.19) ; U4401.G9 v1(134.92,36.9) ; U4301.G9 v1(148.9,44.85) ; U4701.G4 v1(103.36,37.11) ; v1(122.13,31.12) U4601.T9 ; U4701.F12 v1(104.63,29.49) ; U4601.U1 v1(114.96,30.4) ; U4301.U1 v1(155.4,37.64) ; U4701.G9 v1(104.02,32.3) ; U4301.T9 v1(154.75,44.84) ; U4601.G4 v1(117.36,37.56) ; U4401.G4 v1(130.91,36.91) ; U4401.U1 128.54,31.02 v1(128.53,31.02) ; U4701.F1 104.37,39.11 v1(104.64,39.5) ; U4701.U12 v1(97.5,29.91) ; U4301.T4 v1(154.75,40.04) ; U4301.U12 v1(155.4,47.24) ; U4401.T4 v1(130.91,31.05) ; U4701.T9 v1(98.16,32.33) ; U4301.F1 v1(148.26,37.64) ; U4301.G4 v1(148.25,40.85) ; U4601.T4 v1(117.36,31.7)
  TOP w0.3: v1(128.53,31.02) 127.42,31.02 C4507.1
  TOP w0.5: C4503.1 148.64,36.53 148.26,36.91 v1(148.26,37.64) ; C4809.1 96.9,40.13 v1(97.5,39.53) ; v1(114.96,30.4) 114.72,30.63 C4813.1
  TOP w0.508: R244.2 188.01,34.92 187.69,35.24 v2(186.76,35.24) ; Q36.2 188.07,40.8 v2(187.95,40.69)
  IN3 w0.254: 138.43,37.5 135.43,37.5 134.92,36.98 v1(134.92,36.9) ; v1(124.57,38.19) 124.56,38.19 123.89,37.52 122.06,37.52 121.52,36.98 v1(121.36,36.98) ; v1(130.91,36.91) 129.47,36.91 128.52,37.86 v1(128.52,38.19) ; v1(114.94,38.19) 114.94,37.93 115.84,37.03 116.82,37.03 117.35,37.56 v1(117.36,37.56) ; v1(104.64,39.5) 103.82,38.67 103.82,37.71 103.36,37.25 v1(103.36,37.11)
  IN3 w0.508: 138.91,38.19 v1(138.14,38.19)
  IN5 w0.254: v1(155.4,37.64) 154.75,38.29 v1(154.75,40.04)
  IN5 w0.508: v1(124.57,38.19) 124.57,37.83 124.22,37.48
  BOTTOM w0.254: C4814.1 124.61,38.16 v1(124.57,38.19) ; C4516.1 154.76,40.03 v1(154.75,40.04) ; C4514.1 147.61,47.8 v1(147.61,47.26) ; v1(128.52,38.19) 128.46,38.19 128.43,38.16 C4509.1 ; v1(138.11,30.4) 138.12,30.41 C4501.1 ; C4807.1 97.52,36.41 98.16,37.05 v1(98.16,37.15) 98.16,37.17 97.64,37.7 97.64,38.08 98.08,38.52 98.08,38.95 v1(97.5,39.53) ; v1(104.63,29.49) 104.26,29.49 C4805.1 ; v1(148.26,37.64) 148.27,37.63 C4511.1 ; C4816.1 124.67,30.28 v1(124.56,30.4) ; C4803.1 115.46,37.81 115.08,38.19 v1(114.94,38.19) ; C4811.1 104.03,39.44 104.59,39.44 v1(104.64,39.5) ; C4815.1 114.88,30.48 v1(114.96,30.4) ; v1(130.91,31.05) 130.39,31.05 C4504.1 ; v1(97.5,29.91) 97.5,29.65 97.25,29.39 C4801.1 ; v1(138.14,38.19) 138.23,38.28 C4506.1 ; v1(155.4,47.24) 155.38,47.26 C4515.1
  BOTTOM w0.508: v2(186.76,35.24) 186.48,35.24 186.09,35.63 186.09,38.8 187.95,40.66 v2(187.95,40.69) 186.98,40.69 184.85,42.82 183.71,42.82 183.19,42.3 183.19,38.72 178.97,34.5 160.18,34.5 159.4,35.28 v4(159.4,35.88)
  vias: v1(108.48,29.22) v1(109.11,29.22) v1(109.75,29.22) v1(155.79,35.71) v2(148.84,31.63) v2(149.27,32.07) v4(148.26,31.86)
PP1800_EC_G: length 7.6
  TOP w0.203: C122.1 155.1,16.06 v1(155.31,16.27) 155.09,16.27 154.89,16.47 C120.1 154.35,17.36 C116.1 154.35,17.91 v4(153.75,18.51) 153.28,18.51 152.88,18.91 152.61,18.91 152.32,19.2 152.32,19.59 153.16,20.44 U17.F1
  BOTTOM w0.203: v1(155.31,16.27) 155.34,16.29 R136.1
PP1800_G: length 29.2
  TOP w0.254: U36.5 177.88,25.02 177.72,24.86 C298.1 177.52,24.4 175.11,22 175.11,20.72 172.48,18.1 v1(172.1,18.1)
  BOTTOM w0.254: R136.2 157.06,17.27 158.64,15.68 161.59,15.68 162.39,16.48 171.23,16.48 172.1,17.36 v1(172.1,18.1)
PP1800_HP: length 9
  TOP w0.254: R82.2 21.13,32.07 v2(20.72,32.07)
  IN1 w0.254: v2(20.72,32.07) 20.52,32.27 20.52,36.84 20.21,37.15 18.27,37.15 17.61,36.49 v2(17.61,36.41)
PP1800_HP_IO:
  vias: v4(22.85,35.24)
PP1800_LSPK_A:
  vias: v2(19.88,17.71) v2(20.47,17.71) v2(23.24,19.66) v2(23.26,20.25)
PP1800_RSPK_A: length 6.7
  IN4 w0.508: v2(23.64,9.18) 24.5,8.32 26.69,8.32 28.14,9.76 v2(28.14,10.98)
PP1800_SOC_A: length 26.7
  TOP w0.203: v2(94.37,55.26) 94.1,54.98 R314.1 94.1,54.36 94.45,54 R393.1 R392.1
  TOP w0.25: v2(107.43,61.71) 107.08,62.05 U1JSL.CA26
  TOP w0.254: v2(107.41,63.11) U1JSL.BW23 ; v2(107.41,63.11) U1JSL.BW25 ; v2(107.41,63.11) U1JSL.CA25 ; v2(107.41,63.11) U1JSL.CA23 ; U1JSL.CA26 107.05,62.11 v2(107.43,62.47) 107.8,62.15 U1JSL.BW26 ; v2(107.43,61.71) 107.05,61.35 U1JSL.CA28
  IN4 w0.203: v2(104.78,60.73) 104.25,60.21 102.97,60.21 100.68,57.93 97.69,57.93 95.86,56.1 95.04,56.1 94.43,55.48 94.43,55.28 94.4,55.26 v2(94.37,55.26)
  BOTTOM w0.203: v2(107.43,61.71) 106.98,61.26 R6D88.1 ; v2(107.41,63.11) 107.78,63.48 R105.1
  BOTTOM w0.254: C488.1 108,63.01 107.46,62.47 v2(107.43,62.47) ; v2(95.22,73.62) 95.32,73.62 95.65,73.95 96.55,73.95 96.6,73.9 R6D66.1 R6D84.1
  vias: v4(80.92,60.39) v4(80.92,59.75) v4(81.56,61.04) v4(81.55,60.39) v4(81.55,59.75) v4(82.01,62.16)
PP1800_SSD_A: length 53.8
  TOP w0.203: v2(72.37,38.51) 72.92,37.96 R177.1 ; R171.1 75.68,44 v2(75.84,44.15) ; v2(72.92,47.56) 73.23,47.24 R80.1 ; R172.1 R167.1 R173.1 75.37,41.48 74.95,41.06 v2(74.95,40.98) 74.81,40.85 R168.1 ; R175.1 74.13,39.13 74.44,38.82 v2(74.44,38.71) R170.1
  TOP w0.254: U14.N4 U14.P5 67.46,49.33 67.1,49.69 v2(67.1,49.87) ; U14.N4 U14.P3 68.46,49.98 v2(68.46,49.98) ; U14.N4 U14.M4 ; 74.31,49.99 74.26,49.93 R178.1 ; U14.C6 66.96,43.72 v2(66.74,43.94)
  TOP w0.508: R246.2 76.58,50.55 76.02,49.99 72.93,49.99 v2(71.77,48.83)
  IN1 w0.254: v2(72.37,38.51) 73.17,39.3 73.87,39.3 74.44,38.73 v2(74.44,38.71)
  IN4 w0.381: v2(75.84,44.15) 75.84,43.36 74.95,42.47 v2(74.95,40.98) 74.95,40.52 74.44,40.01 v2(74.44,38.71) ; v2(75.84,44.15) 75.76,44.23 72.32,44.23 72.04,44.51 67.29,44.51 66.74,43.96 v2(66.74,43.94) ; v2(75.84,44.15) 75.84,46.04 74.82,47.05 73.42,47.05 v2(72.92,47.56) 72.92,47.69 v2(71.77,48.83) 69.49,51.12 67.84,51.12 67.1,50.38 v2(67.1,49.87)
  BOTTOM w0.254: v2(66.74,43.94) 66.35,43.94 C67.1
  BOTTOM w0.508: C65.1 68.99,50.45 68.63,50.1 68.58,50.1 v2(68.46,49.98) 67.99,50.46 67.48,50.46 67.1,50.08 v2(67.1,49.87)
PP3000_RTC: length 87.7
  TOP w0.2: U1JSL.CL49 102.8,51.79 v2(102.85,51.74)
  TOP w0.254: R3C22.1 R3C23.1 86.84,41.3 86.64,41.1 85.88,41.1 v2(85.66,40.88) ; v2(85.98,13.59) D24.1 84.96,13.59 C1A6.1 ; v2(91.16,43.46) 91.02,43.32 R3C18.1
  IN2 w0.508: v2(85.98,13.59) 106.51,13.59 106.95,14.03 v2(108.69,14.03)
  BOTTOM w0.508: v2(91.16,43.46) 91.16,42.33 90.83,42 90.3,42 89.19,40.88 v2(85.66,40.88) 85.66,40.37 v4(88.16,37.87) 88.16,30.84 91.36,27.64 93.06,27.64 93.33,27.9 107.63,27.9 111.4,24.13 111.4,22.95 v4(113.87,20.48) 113.87,18.59 110.86,15.58 109.26,15.58 108.69,15.01 v2(108.69,14.03)
PP3300_A: length 497
  TOP w0.178: Q28.1 64.22,66.37 v2(64.69,66.84)
  TOP w0.203: v2(74.06,29.49) 74.53,29.02 74.53,28.22 74.41,28.1 R273.1 ; v1(151.36,15.59) 150.72,15.59 150.18,16.13 149.13,16.13 148.97,16.29 R317.2 ; v2(93.95,65.62) 93.19,66.38 92.79,66.38 92.13,67.04 92.13,68.61 92.42,68.9 92.42,69.38 91.69,70.12 v2(91.69,70.22) ; R339.1 90.14,43.49 90.21,43.41 90.21,43.04 v2(90.19,43.01) ; v2(140.29,73.77) 140.29,73.45 R322.1 ; R230.2 46.45,58.48 45.65,59.28 v2(45.65,59.53) ; R51.1 R62.1 164.17,27.92 164.15,27.9 164.15,27.9 164.13,27.93 v1(164.13,27.95) ; R320.1 90.03,34.44 90.03,34.91 v2(90.04,34.91) ; v2(164.22,79.48) 164.22,79.15 R456.1 ; R114.1 174.48,57.46 175.15,57.46 v2(175.48,57.79) 175.48,57.76 175.63,57.61 R27106.1
  TOP w0.254: R253.1 64.31,67.22 v2(64.69,66.84)
  TOP w0.381: v2(91.98,26.71) 92.33,27.06 93.15,27.06 94.5,25.72 95.01,25.72 96.44,24.29 R91317.1
  TOP w0.508: 185.26,42.32 185.36,42.32 185.79,41.89 185.79,41.71 186.15,41.35 186.15,40.55 186.44,40.26 187.1,40.26 187.32,40.04 187.32,38.89 v2(187.55,38.66) ; v2(183.02,45.84) 183.42,45.84 183.91,45.34
  IN1 w0.381: v2(90.19,43.01) 90.19,41.84 89.17,40.83 89.17,35.7 89.96,34.91 v2(90.04,34.91) 89.17,34.05 89.17,29.53 v2(91.98,26.71) ; v1(164.13,27.95) 165.95,27.95 166.52,27.39 167.45,27.39 167.71,27.65 169.28,27.65 170.58,26.35 171.48,26.35 172.38,25.45 172.38,25.21 v2(172.7,24.89)
  IN1 w0.508: v2(164.22,79.48) 164.09,79.61 148.65,79.61 v2(145.68,82.59) 140.29,77.2 v2(140.29,73.77)
  IN1 w1.016: 26.31,42.99 26.31,44.25 27.14,45.08 27.14,45.75 30.56,49.17 30.56,51.54 31.66,52.63 31.66,53.07 33.01,54.42 34.56,54.42 36.34,56.2
  IN2 w0.381: v2(187.55,38.66) 187.55,38.63 186.1,37.18 186.1,26.64 185.35,25.89 182.67,25.89 182.15,26.41 179.39,26.41 178.9,25.92 v2(178.9,25.55) 176.07,25.55 175.11,24.6 172.99,24.6 v2(172.7,24.89)
  IN2 w0.508: 45.63,66.14 46.52,67.04 52.97,67.04 53.74,67.8 53.74,68.59 54.5,69.35 61.16,69.35 62.12,68.39 64.08,68.39 65.09,69.4 v2(65.09,69.86) ; v2(183.02,45.84) 183.02,46.14 182.81,46.35 v2(182.81,47.89) 183.08,47.89 183.53,48.35 183.53,69.61 175.39,77.75 165.78,77.75 164.28,79.24 164.28,79.25 164.22,79.31 v2(164.22,79.48) ; v2(59.79,39.1) 59.79,39.01 60.68,38.11 61.67,38.11 62.66,39.1 68.41,39.1 69.5,38.01 69.5,37.71 72.67,34.55 72.67,30.88 v2(74.06,29.49) ; v2(95.24,72.66) 95.27,72.66 96.59,73.98 100.89,73.98 102.49,75.58 103.96,75.58 104.79,74.74 107.71,74.74 108.22,75.25 108.22,76.39 108.73,76.9 110.64,76.9 111.16,76.38 124.59,76.38 125.44,77.22 128.98,77.22 129.52,77.76 129.52,78.89 130.47,79.84 132.13,79.84 133.17,78.8 134.88,78.8 135.69,77.99 140.07,77.99 144.24,82.16 145.26,82.16 v2(145.68,82.59)
  IN2 w1.016: 36.47,58.61 36.47,59.75 37.04,60.32 37.04,62.21 38.19,63.37 40.77,63.37 40.94,63.2 42.87,63.2 45.13,65.45
  IN3 w0.254: v2(172.7,24.89) 172.19,24.89 171.21,23.91 170.86,23.91 166.82,19.87 164.79,19.87 162.17,17.26 158.77,17.26 157.29,15.78 151.55,15.78 v1(151.36,15.59)
  IN3 w0.381: v2(91.69,70.22) 91.69,70.5 92.09,70.9 94.94,70.9 95.24,71.21 v2(95.24,72.66)
  IN4 w0.381: v2(45.97,66.02) 45.58,65.62 v2(45.58,65.55) 44.83,64.81 44.83,60.35 v2(45.65,59.53) ; 36.59,56.96 36.59,56.25 41.86,50.99 44.3,50.99 51.56,43.73 62.53,43.73 62.89,43.37 70.5,43.37 73.26,40.61 73.26,39.22 73.77,38.72 v2(73.79,38.72) 73.79,38.57 74.06,38.31 v2(74.06,29.49)
  IN4 w0.508: v2(182.81,47.89) 182.55,47.89 182.2,48.24 182.2,51.16 183.51,52.46 183.51,55.71 183.15,56.07 181.76,56.07 179.98,57.85 175.54,57.85 v2(175.48,57.79)
  BOTTOM w0.178: R403.1 102.68,70.01 102.61,70.08 R144.1
  BOTTOM w0.203: R144.1 102.16,70.08 102,69.92 ; v2(93.95,65.62) 93.74,65.42 93.74,64.45 94.08,64.12 R11.1 R2.1 ; R403.1 103.91,70.19 103.91,70.66 104.18,70.93 R117.1 ; R103.1 101.91,69.23 102,69.32 102,69.92 ; R30.1 R3.1 73.23,71.12 ; R291.2 59.42,39.67 59.79,39.3 v2(59.79,39.1) 59.79,38.41 59,37.61 58.6,37.61 58.08,37.1 R292.2 ; 102,69.92 101.83,70.08 101.32,70.08 100.7,70.7 100.22,70.7 100.02,70.9 99.46,70.9 98.87,70.3 98.42,70.3 98.13,70.6 97.36,70.6 97.05,70.92 97.05,70.98 96.54,71.49 95.73,71.49 95.24,71.97 v2(95.24,72.66)
  BOTTOM w0.254: R48.2 91.62,70.29 v2(91.69,70.22)
  BOTTOM w0.381: D9.1 179.24,25.1 178.9,25.44 v2(178.9,25.55) ; v2(73.79,38.72) 73.79,39.03 74.03,39.27 77.72,39.27 80.12,41.67 83.92,41.67 84.94,42.69 86.67,42.69 87.54,43.56 89.74,43.56 90.19,43.12 v2(90.19,43.01)
  BOTTOM w0.508: v2(95.24,72.66) 94.43,72.66 93.11,73.98 92.6,73.98 88.75,77.82 77.4,77.82 73.66,74.08 73.66,71.54 73.23,71.12 71.97,72.39 69.9,72.39 68.51,71 66.23,71 v2(65.09,69.86) 64.69,69.45 v2(64.69,66.84)
  vias: v2(36.09,57.34) v2(36.67,57.34) v4(26.05,42.53) v4(26.05,41.9) v4(35.37,57.01)
PP3300_A_R:
  vias: v4(34.33,53.45)
PP3300_AP_FLASH: length 26
  IN2 w0.381: v2(171.19,31.08) 171.19,29.74 169.93,28.48 169.93,26.11 169.72,25.89 169.72,24.53 169.83,24.42 169.83,22.33 170.15,22.01 174.15,22.01 v2(174.58,21.58) 174.59,21.58 176.97,23.95 v2(178.54,23.95)
  BOTTOM w0.203: R59.1 174.59,21.57 v2(174.58,21.58)
  BOTTOM w0.381: v2(178.54,23.95) 178.35,24.14 178.35,25.89 178.7,26.24 D9.3 ; v2(174.58,21.58) 174.41,21.75 C20.1 173.91,22.19 173.84,22.25 U11.8
PP3300_CAMERA_USER:
  vias: v2(46.96,63.77) v2(46.96,63.18)
PP3300_DISPLAY_S0:
  vias: v2(54.6,59.52) v2(54.91,60.03) v2(55.24,59.52) v4(39.54,56.96) v4(39.53,56.32) v4(40.1,56.63) v4(54.68,58.79)
PP3300_EC_G: length 119.9
  TOP w0.203: U17.M10 157.59,26.29 v1(157.61,26.32) 159,26.32 159.54,26.86 R142.1 160.21,26.86 160.57,26.49 R137.1 R134.1 ; v1(159.07,27.7) 159.86,27.7 160.14,27.97 R128.1 ; v1(160.29,30.57) 160.14,30.41 R126.1 ; v1(150.39,19.82) 150.51,19.95 150.51,20.32 U17.B1 ; U17.M8 157.57,24.99 v1(157.63,24.94) ; v1(148.86,24.42) 149.47,24.42 149.55,24.34 U17.A7 ; v1(151.38,28.56) 151.38,28.31 151.94,27.75 U17.D12 ; v1(151.81,16.39) 151.81,17.17 FB1.2 ; U17.L4 v1(156.81,22.07) ; U17.H12 154.54,27.92 154.3,28.15 v1(154.3,28.56)
  TOP w0.254: v1(146.11,24.78) R27293.1
  TOP w0.508: 145.97,22.46 145.18,22.46 144.72,22.01 137.33,22.01 136.58,22.75 119.82,22.75 119.73,22.67 v4(112.79,22.67) 112.41,22.29 99.21,22.29 99.08,22.41 v2(99.08,22.44)
  IN1 w0.254: v1(148.86,24.42) 148.86,24.23 148.57,23.94 146.8,23.94 v2(146.22,23.36) 146.11,23.47 v1(146.11,24.78)
  BOTTOM w0.203: C117.1 149.16,23.96 148.86,24.26 v1(148.86,24.42) 148.99,24.55 C111.1 ; C111.1 150.24,24.55 150.26,24.57 R27294.1 ; C111.1 150.01,24.27 149.94,24.2 R123.1 R121.1 149.94,22.74 150.39,22.29 150.39,21.32 150.83,20.88 R937.1 152.01,20.15 151.68,19.82 v1(150.39,19.82) ; v2(99.08,22.44) 97.88,21.24 R256.1 ; C123.1 153.73,18.46 151.81,16.53 v1(151.81,16.39)
  BOTTOM w0.254: 151.38,28.43 151.38,27.98 151.02,27.62 149.88,27.62 149.42,27.16 149.42,25.99 149.65,25.76 R27301.1 149.29,25.67 148.86,25.24 v1(148.86,24.42) ; 151.38,28.43 v1(151.38,28.56) ; 151.38,28.43 152.07,27.74 C121.1 152.07,27.2 152.17,27.09 154.42,27.09 154.61,26.91 R140.1 ; R140.1 154.83,27.49 C113.1 154.75,27.81 154.3,28.27 v1(154.3,28.56) ; R140.1 155.06,27.14 155.16,27.14 155.2,27.18 C124.2 R125.2 156.99,26.41 C115.1 157.6,26.33 v1(157.61,26.32) ; v1(157.63,24.94) 157.22,25.34 R139.1 ; v1(157.63,24.94) 157.83,24.74 158.53,24.74 158.79,24.47 158.79,22.87 158.64,22.72 158.64,21.4 158.26,21.02 156.89,21.02 156.75,21.15 C119.1 ; v1(157.63,24.94) 157.74,24.94 158.03,25.24 158.03,25.9 v1(157.61,26.32) ; C123.1 154.83,18.46 155.26,18.9 155.26,20.51 155.39,20.64 R27291.2 155.77,21.13 155.79,21.15 C119.1 ; v1(156.81,22.07) 156.45,21.71 R423.2 C119.1 ; v1(157.61,26.32) 157.84,26.32 159.07,27.54 v1(159.07,27.7) 160.29,28.92 v1(160.29,30.57)
PP3300_G: length 101.2
  TOP w0.508: v4(26.11,45.34) 26.56,45.79 27.05,45.79 27.7,46.43 28.79,46.43 29.78,47.42 31.94,47.42 R266.2
  IN1 w0.508: v1(163.8,29.78) 164.14,29.44 166.55,29.44 166.69,29.3 170.96,29.3 172.14,30.48 172.82,30.48 173.29,30.95 175.18,30.95 175.7,30.43 177.92,30.43 v4(178.57,29.78) ; v2(6.5,13.59) 6.58,13.68 6.58,15.01 13.48,21.91 13.48,25.08 15.48,27.08 16.35,27.08 17.3,28.03 v2(17.3,29.47)
  IN2 w0.508: v4(26.11,45.34) 26.11,45.09 26.66,44.54 26.66,38.44 22.62,34.4 22.62,32.25 20.66,30.29 18.12,30.29 v2(17.3,29.47) ; 39.77,50.1 39.77,55.14 40.37,55.74 41.73,55.74 42.35,56.37 42.35,60.81 47.19,65.64 v4(47.19,66.05)
  BOTTOM w0.508: v1(163.8,29.78) 162.83,29.78 160.89,31.72 158.3,31.72 157.24,30.67 157.24,28.22 R125.1 ; 41.17,45.53 41.17,46.29 41.04,46.42 41.04,48.58 v2(40.02,49.59)
  vias: v2(42.85,37.37) v4(39.39,49.59) v4(55.26,21.86)
PP3300_G_R: length 12.8
  TOP w0.203: v2(39.25,44.26) 39.41,44.1 U30.10
  TOP w0.254: v2(38.8,46.64) 38.8,46.9 C257.2
  BOTTOM w0.254: v2(30.15,46.33) 30.45,46.64 v2(38.8,46.64) 38.8,44.71 v2(39.25,44.26)
  vias: v4(31.27,38.89)
PP3300_H1_G: length 79.7
  TOP w0.079: v1(162.52,18.89) 162.86,19.24 163.07,19.24 163.18,19.34 163.75,19.34 U13.B2 ; v1(167.39,18.56) 167,18.95 U13.H1
  TOP w0.203: R74.1 161,22.43 161.45,22.88 C52.1 161.45,23.14 v1(161.99,23.68) 161.99,23.34 163.24,22.1 U13.A7 ; v1(164.64,25.67) 164.38,25.41 R63.1 164.61,25.23 164.91,24.93 165.2,24.93 C51.1 165.27,24.91 165.27,24.9 165.5,24.67 U13.E9 ; v1(159.91,20.25) 160.29,20.25 160.4,20.15 R12.1 R73.1
  TOP w0.254: v1(168.04,20.36) 167.8,20.6 U13.J4 ; R71.1 166.91,16.73 167.39,17.2 v1(167.39,18.56) ; Q15.2 171.47,23.89 171.2,23.62 R65.1 170.67,23.74 v2(170.67,24.47) 170.32,24.47 170.25,24.4 R67.2
  TOP w0.381: v1(162.52,18.89) 161.37,18.89 160.77,18.29 Q22.2 160.01,18.8 159.91,18.9 v1(159.91,20.25)
  TOP w0.508: v2(179.65,25.55) 179.65,26.2 179.09,26.76 R399.2
  IN1 w0.381: v1(164.64,25.67) 164.64,26.22 164.93,26.5 166.44,26.5 167.91,25.03 169.37,25.03 169.93,24.47 v2(170.67,24.47) ; v1(167.39,18.56) 167.39,18.85 167.15,19.09 162.71,19.09 v1(162.52,18.89)
  IN2 w0.508: v2(179.65,21.02) 183.74,21.02 J1.1 ; v1(159.91,20.25) 161.3,21.64 161.3,22.13 161.99,22.83 v1(161.99,23.68) ; v2(179.65,25.55) 179.65,25.33 179.22,24.9 176.41,24.9 175.33,23.82 171.32,23.82 v2(170.67,24.47)
  IN4 w0.508: v2(179.65,25.55) v2(179.65,21.02)
  BOTTOM w0.203: v1(167.39,18.56) 167.44,18.6 C53.1 C50.1 168.03,20.37 v1(168.04,20.36)
  BOTTOM w0.254: 170,28.55 170.24,28.79 C28016.2 170.87,29.15 170.37,29.66 U42.5 ; Q6.1 180.51,20.72 R55.1 179.95,20.71 v2(179.65,21.02)
  BOTTOM w0.381: v1(167.39,18.56) 167.38,18.55 C61.1 R75.1
  BOTTOM w0.508: v1(164.64,25.67) 164.53,25.67 163.26,24.41 ; 170,28.55 169.83,28.38 169.83,27.06 170.35,26.54 171.44,26.54 172.09,25.89 172.09,24.47 171.87,24.26 170.88,24.26 v2(170.67,24.47)
PP3300_HP_VBAT:
  vias: v4(24.48,43.78)
PP3300_LDO_Z: length 374.9
  TOP w0.203: Q18.1 86.2,14.3 86.18,14.28 D24.2 R296.1 85.82,15.08 v2(86.09,14.82) ; R301.2 42.12,46.23 42.31,46.42 v2(42.31,46.8) ; v2(122.79,21.37) 123.58,21.37 124.11,21.89 R99.1 ; v2(66.27,16.46) 66.16,16.57 C187.1 66.16,17.38 65.57,17.97 64.54,17.97 64.44,17.87 U9.25
  TOP w0.254: U1.5 174.1,28.84 C130.2 174.49,29.63 174.34,29.78 v2(174.34,30.21) ; U6582.3 14.79,68.27 15.13,67.93 C1045.2 v2(15.51,68.54)
  IN1 w0.254: v2(106.65,16.61) 105.61,17.65 88.28,17.65 86.09,15.45 v2(86.09,14.82) ; v2(187.51,33.67) 186.99,34.19 186.43,34.19 185.91,33.67 185.91,32.8 184.4,31.29 179.95,31.29 179.28,30.62 179.28,29.48 178.94,29.13 175.2,29.13 174.34,30 v2(174.34,30.21) 172.79,28.66 165.83,28.66 165.58,28.41 162.95,28.41 161.74,27.2 v1(161.74,27.19)
  IN2 w0.254: v2(42.31,46.8) 43.52,48 43.52,60.98 v2(45.83,63.3) ; v2(191.72,58.65) 191.77,58.6 191.77,54.57 189.72,52.51 189.72,40.03 187.81,38.12 187.81,33.97 v2(187.51,33.67) ; v2(171.47,24.9) 171.47,25.79 172.74,27.06 172.74,28.61 v2(174.34,30.21) ; v2(86.09,14.82) 84.76,16.15 78.29,16.15 77.55,16.89 69.28,16.89 68.71,16.32 66.41,16.32 v2(66.27,16.46) ; v2(48.94,70.42) 48.09,71.27 43.71,71.27 43.43,70.99 38.94,70.99 37.42,69.47 36.37,69.47 35.22,68.32 34.27,68.32 33.51,69.09 28.07,69.09 23.47,64.49 18.67,64.49 15.51,67.65 v2(15.51,68.54)
  IN4 w0.254: v1(161.74,27.19) 161.74,27.2 162.07,27.53 162.07,29.54 160.43,31.18 155.07,31.18 154.62,30.73 154.62,29.96 154.07,29.41 150.54,29.41 149.9,28.77 149.9,27.08 146.67,23.85 145.97,23.85 145.67,23.55 145.67,23.19 144.11,21.63 143.68,21.63 143.38,21.32 143.38,19.9 142.27,18.79 138.94,18.79 137.55,20.18 134.88,20.18 133.53,21.52 122.95,21.52 v2(122.79,21.37) 122.79,21.3 122.04,20.55 110.14,20.55 109.28,19.7 108.17,19.7 107.64,20.23 106.4,20.23 105.46,21.17 93.21,21.17 v2(92.45,21.93) ; v2(72.09,19.72) 69.11,22.71 69.11,27.12 70.88,28.9 70.88,30.68 70,31.57 70,39 68.83,40.16 62.54,40.16 61.95,40.76 51.42,40.76 45.38,46.8 v2(42.31,46.8) ; v2(48.94,70.42) 49.32,70.04 52.28,70.04 53.04,69.28 53.04,66.61 51.85,65.42 49.07,65.42 48.48,64.83 46.5,64.83 45.83,64.17 v2(45.83,63.3)
  BOTTOM w0.203: 158.59,26.38 158.49,26.28 R91365.1 R91364.1
  BOTTOM w0.254: v2(187.51,33.67) 187.72,33.88 R204.1 ; v2(66.27,16.46) 67.28,16.46 70.54,19.72 v2(72.09,19.72) ; v1(161.74,27.19) 161.36,27.57 159.78,27.57 158.59,26.38 ; v2(171.47,24.9) 171.47,25.53 171.23,25.77 R155.1 ; J12.4 v2(191.72,58.65) ; v2(106.65,16.61) 106.65,17.41 106.3,17.75 106.3,19.18 104.6,20.88 101.88,20.88 97.95,24.81 90.27,24.81 90.1,24.64 90.1,23.05 90.33,22.83 C28023.1 91.49,22.83 91.89,23.23 C28022.1 92.26,22.12 v2(92.45,21.93) R255.1
PP3300_MIPI60: length 5.1
  BOTTOM w0.114: R41.1 89.88,69.12 89.98,69.22 R47.1 89.98,69.99 R48.1 v4(89.48,70.29) 89.09,69.9 88.37,69.9 J15.52
PP3300_PANEL_S0:
  vias: v4(39.99,52.59)
PP3300_PP1800_VCCPGPPR: length 1.9
  TOP w0.254: U1JSL.BW28 107.81,61.35 v2(108.19,61.71)
  BOTTOM w0.203: R6D88.2 R35.2 107.97,61.49 v2(108.19,61.71)
PP3300_SOC_A: length 92.8
  TOP w0.109: R381.1 94.13,59.41 94.52,59.8
  TOP w0.152: R419.1 93.99,70.63 93.73,70.89 93.25,70.89 93.04,70.68 R415.1
  TOP w0.178: v2(95.52,60.01) 95.5,59.98 95.41,59.98 95.23,59.8 94.52,59.8
  TOP w0.203: v2(92.27,70.22) 92.27,70.01 92.75,69.53 92.75,68.72 92.5,68.47 R6D34.1 92.5,67.14 92.93,66.71 93.4,66.71 93.86,66.25 R1G3.1 94.53,65.91 94.95,65.91 95.44,65.42 R1H18.1 96.06,65.62 96.7,66.26 R6D41.1 ; R424.1 15.74,30.32 16.11,30.68 v2(16.11,30.98) ; R383.1 94.13,61.53 94,61.4 94,60.89 v2(94.05,60.84) 94.2,60.84 94.28,60.92 R3C14.1 94.51,61.15 94.7,61.34 94.82,61.34 94.89,61.4 95.56,61.4 95.77,61.61 R380.1 ; v2(95.52,60.01) 95.55,60.01 95.65,60.11 R382.1 ; R354.1 101.41,45.62 v1(100.93,45.62) ; R7D35.1 96.06,68.64 95.85,68.85 95.67,68.85 95.64,68.88 95.6,68.88 v2(95.59,68.87) 95.59,68.9 95.57,68.92 95.24,68.92 R417.1 ; v2(95.09,46) 94.86,45.78 R8702.1 ; R404.1 91.67,47.67 92.08,47.67 v2(92.21,47.79) 92.21,47.78 92.21,47.57 R7D26.1
  TOP w0.25: v2(108.19,60.24) U1JSL.BW30 ; v2(107.43,60.24) U1JSL.CA30
  TOP w0.254: U1JSL.BW31 v2(108.19,60.24) ; R419.1 94.41,70.5 R4F23.1 ; U1JSL.BW34 v2(107.43,58.79) U1JSL.CA34 ; U1JSL.CA31 v2(107.43,60.24) ; v2(95.59,69.99) 95.74,70.14 R7D25.1 96.51,70.14 96.69,70.32 R7D40.1 ; R415.1 92.57,70.68 92.48,70.77 R413.1 92.27,70.23 v2(92.27,70.22) ; v2(102.99,52.76) 102.96,52.74 U1JSL.CK48 ; U1JSL.BW33 v2(108.19,59.51) ; U1JSL.CA33 v2(107.43,59.51)
  IN1 w0.508: v2(31.96,50.13) 32.28,50.13 32.94,50.79 32.94,53.06 33.41,53.53 35.07,53.53 37.4,55.86 v4(37.4,56.31)
  IN2 w0.381: v2(95.09,46) 95.09,46.2 94.43,46.85 92.75,46.85 92.21,47.4 v2(92.21,47.79)
  IN4 w0.254: v2(95.59,68.87) v2(95.59,69.99) 95.59,72.14 96.03,72.58 96.03,73.72 95.52,74.23 v2(95.22,74.23)
  BOTTOM w0.203: R6D40.1 R6C1.1 102.88,73.59 102.61,73.31 R6D46.1 R6D42.1 R6D39.1 100.53,73.31 100.19,72.97 ; R8A7.1 95.77,68.72 95.62,68.87 v2(95.59,68.87) ; R4E63.1 96.05,69.92 95.66,69.92 v2(95.59,69.99) ; R20.1 108.55,54.56 v2(108.47,54.64) ; R6D67.1 95.65,73.14 95.02,73.14 94.69,73.47 94.69,73.85 95.06,74.23 v2(95.22,74.23)
  BOTTOM w0.254: R6D85.1 100.19,73 100.09,73.1 100.09,73.85 99.49,74.45 95.41,74.45 95.22,74.26 v2(95.22,74.23) ; C48.1 103.15,52.6 v2(102.99,52.76)
  BOTTOM w0.508: v2(31.96,50.13) 31.96,50 31.29,49.33 31.29,49 30.94,48.65 30.94,47.99 27.96,45.01 27.96,40.32 25.67,38.03 25.67,36.36 22.98,33.67 22.98,33.13 20.19,30.33 16.75,30.33 v2(16.11,30.98)
  vias: v4(37.41,56.96) v4(37.71,55.74) v4(38.05,56.96) v4(38.05,56.32) v4(38.68,56.96) v4(38.68,56.32) v4(96.87,45.2)
PP3300_SSD_A: length 24.3
  TOP w0.254: U14.E6 v2(66.96,44.94) U14.F5
  IN4 w1.524: 41.93,53.91 43.76,52.08 46.17,52.08 53.45,44.8 61.43,44.8
  vias: v2(40.92,54.63) v2(40.91,54.04) v2(40.91,53.45) v2(65.46,46.44) v2(66.04,46.44) v2(66.69,45.48) v4(30.61,56.73) v4(30.97,56.19) v4(31.29,56.73) v4(31.92,56.75) v4(65.45,45.02)
PP3300_THRM:
  vias: v4(97.06,24.9)
PP3300_THRM_R:
  vias: v4(99.68,23.58)
PP3300_TOUCH_S0: length 106.5
  TOP w0.254: v2(31.91,49.06) 31.68,48.83 C96.1 30.98,48.93 31.51,49.46 31.51,49.72 31.31,49.92 U35.3
  IN1 w0.254: v2(79.21,55.73) 75.84,52.36 75.84,51.37 73.98,49.52 71.6,49.52 71.5,49.42 70.02,49.42 69.87,49.26 65.42,49.26 64.71,48.55 v2(62.25,48.55)
  IN2 w0.254: v2(79.21,55.73) 79.25,55.78 89.66,55.78 v2(90.3,56.41) ; v2(62.25,48.55) 62.25,47.2 60.09,45.05 54.44,45.05 53.65,45.84 53.65,53.27 53.28,53.64 52.69,53.64 v2(52.36,53.96)
  IN4 w0.254: v2(52.36,53.96) 50.18,53.96 49.73,54.41 47.46,54.41 46.52,53.46 44.34,53.46 42.62,55.17 40.7,55.17 40.18,54.65 40.18,53.49 v2(40.9,52.77)
  BOTTOM w0.254: v2(90.3,56.41) 91.31,56.41 92.9,58 v4(93.49,58) 94.86,59.37 95.73,59.37 96,59.65 96,59.86 96.06,59.92 R325.1 R326.1 ; v2(62.25,48.55) 61.89,48.55 60.85,49.59 60.85,51.69 61.64,52.47 61.64,59.47 61.33,59.78 v4(59.4,59.78) 58.75,60.43 J23.35 ; v2(40.9,52.77) 40.87,52.77 40.18,52.08 34.93,52.08 31.91,49.06 v2(31.91,49.06)
PP3300_TRACKPAD_A: length 182.4
  TOP w0.203: v1(162.2,25.7) 162.1,25.7 160.5,24.09 159.95,24.09 v2(159.66,24.38)
  TOP w0.508: R252.2 v2(30.67,52.86)
  IN2 w0.508: v2(47.26,28.8) 47.26,29.04 47.81,29.59 51.28,29.59 53.08,31.4 60.49,31.4 71.58,20.31 77,20.31 79.18,18.13 83.59,18.13 85.75,20.28 90.7,20.28 94.11,16.86 94.11,16.17 94.69,15.6 101.66,15.6 102.49,16.42 102.49,17.11 103.1,17.72 105.28,17.72 105.78,18.22 110.56,18.22 114.19,14.59 143.35,14.59 147.87,19.11 151.37,19.11 151.66,18.81 155.03,18.81 155.73,18.12 157.09,18.12 157.63,18.65 157.63,20.13 158.3,20.8 159.13,20.8 159.66,21.32 v2(159.66,24.38)
  IN4 w0.508: v2(30.67,52.86) 30.86,52.66 30.86,49.2 28.68,47.02 28.68,32.1 31.39,29.39 39.18,29.39 39.78,28.8 v2(47.26,28.8)
  BOTTOM w0.203: R199.1 161.53,25.13 162.15,25.74 162.18,25.74 162.2,25.72 v1(162.2,25.7)
  BOTTOM w0.254: J18.6 159.65,23.69 160.11,24.15 160.11,24.73 C148.1 159.99,24.8 159.66,24.47 v2(159.66,24.38)
PP3300_USB_C0_G: length 221.1
  TOP w0.178: U6.7 33.88,63.36 v2(33.89,63.37) ; U6.13 33.82,65.76 v2(33.89,65.7) ; U6.10 33.84,64.56 v2(33.89,64.51) ; U8.10 40.04,67.14 40.13,67.05 40.78,67.05 41.29,66.53 v2(41.29,66.36) ; U6.1 33.59,60.96 33.77,61.15 v2(33.91,61.15)
  TOP w0.203: v2(29.34,61.75) 29.36,61.76 U6.32 ; R210.1 29.28,67.95 v2(29.16,68.07) ; v2(29.32,64.16) U6.26 ; U6.4 33.8,62.16 v2(33.91,62.28) ; v2(29.32,65.36) U6.23 ; v2(29.32,62.96) U6.29
  TOP w0.508: v2(180.38,25.55) 180.38,26.78 R398.2
  IN2 w0.508: v4(180.29,22.66) 179.56,22.66 174.11,17.21 168.29,17.21 163.02,11.94 111.71,11.94 108.86,14.79 104.64,14.79 v2(104.17,14.32) ; v2(41.29,66.36) 41.29,65.34 40.66,64.7 36.31,64.7 35.93,65.09 34.17,65.09 33.89,65.37 v2(33.89,65.7) ; v2(103.22,20.34) 103.22,20.37 102.44,21.14 94.59,21.14 93.18,22.56 89.12,22.56 87.03,24.64 82.87,24.64 80.5,22.26 72.27,22.26 64.35,30.19 64.35,30.68 60.23,34.79 57.76,34.79 56.72,35.83 52.46,35.83 51.17,37.12 51.17,45.24 46.71,49.7 46.71,49.7 44.44,51.98 44.44,60.4 45.72,61.69 46.32,61.69 47.56,62.92 47.56,63.7 48.1,64.25 v2(48.1,65.35)
  IN4 w0.508: v2(48.1,65.35) 47.01,65.35 46.57,65.8 46.57,67.09 45.63,68.03 42.95,68.03 41.29,66.37 v2(41.29,66.36)
  BOTTOM w0.508: v2(180.38,25.55) 181.37,25.55 182.11,24.81 182.11,23.48 181.29,22.66 v4(180.29,22.66) ; v2(103.22,20.34) 104.41,20.34 105.78,18.97 105.78,17.47 106.03,17.23 106.03,16.35 104.17,14.49 v2(104.17,14.32)
PP3300_WLAN_A: length 6.5
  TOP w0.203: C106.2 42.74,15.6 42.39,15.95 R113.1
  BOTTOM w0.203: v2(34.89,26.73) 34.89,26.86 35.24,27.21 35.79,27.21 36.17,26.84 C102.2 36.3,27.28 36.39,27.38 U16.5 ; v2(34,26.73) R112.2 R111.1 ; R116.1 32.65,24.54 33.04,24.93 v2(33.04,25.33)
  vias: v2(32.15,12.08) v2(32.15,11.49) v2(32.15,10.91) v2(33.57,57.44) v2(33.57,56.85) v2(34.1,57.16) v2(34.1,56.58) v2(43.6,11.83) v2(43.6,11.24) v2(43.6,10.64) v2(43.78,14.65) v2(43.78,14.07) v2(43.78,13.48) v4(32.96,57.52)
PP3300A_EC_G: length 5
  TOP w0.079: U17.D1 151.94,19.98 v4(151.45,19.49) 151.45,19.12 151.75,18.82
  TOP w0.109: 151.75,18.82 151.78,18.79 FB1.1 151.32,17.65 151.24,17.56 C114.1 150.94,17.25 150.95,17.24 C118.1
PP5000_CHARGER_INT: length 4.8
  TOP w0.203: v2(65.51,16.89) 65.38,17.02 64.47,17.02 64.41,17.07 U9.23
  BOTTOM w0.508: R1004.2 66.02,19.08 66.19,18.92 66.19,17.09 C200.1 65.8,17.08 65.61,16.89 v2(65.51,16.89)
PP5000_CHARGER_INT_R: length 11.4
  TOP w0.203: U9.1 58.95,19.87 58.5,20.32 58.5,21.09 C202.1
  TOP w0.508: C202.1 57.94,22.17 v2(58.06,22.29)
  BOTTOM w0.508: R1004.1 64.53,19.49 63.92,20.1 59.73,20.1 58.06,21.78 v2(58.06,22.29)
PP5000_IMVP9_PVCC: length 3.8
  TOP w0.203: U10.29 177.2,53.42 176.57,52.79 v4(176.57,52.66)
  TOP w0.508: R131.2 175.57,51.55 175.87,51.85 C231.1 176.57,52.19 v4(176.57,52.66)
PP5000_IMVP9_VCC: length 5.7
  TOP w0.203: U10.10 182.15,52.62 182.78,51.99
  TOP w0.508: 182.78,51.99 183.43,51.34 C27104.1 183.94,51.34 184.61,50.67 v2(184.61,49.73)
  BOTTOM w0.508: R27115.2 184.14,49.73 v2(184.61,49.73)
PP5000_LSPK_U: length 9.1
  BOTTOM w1.016: 21.61,25.33 18.56,25.33 17.54,24.32 17.54,22.41 16.91,21.78 15.13,21.78
  vias: v2(14.31,22.06) v2(14.31,21.47) v2(22.62,25.64) v2(22.62,25.06)
PP5000_RSPK_U: length 11.7
  TOP w0.508: R91357.1 19.96,14.69 v2(20.26,15) ; R91356.1 19.78,11.56 v2(19.78,10.93)
  BOTTOM w1.016: 28.21,15.05 28.21,12.89 26.18,10.86 22.01,10.86 21.43,11.44
  vias: v2(28.21,16.57) v2(28.21,15.94)
PP5000_U: length 301.4
  TOP w0.203: 182.23,43.21 U22.12
  TOP w0.254: U33.8 58.52,38.37 58.41,38.48 58.13,38.48
  TOP w0.508: 58.13,38.48 57.32,38.48 56.87,38.94 C280.1 57.58,39.14 v2(57.61,39.12) ; v2(72.67,29.45) 73.11,29.01 R447.1 ; v2(183.03,44.47) 182.79,44.47 182.41,44.09 C363.1 182.21,43.23 182.23,43.21 ; 182.52,57.34 184.17,55.69 184.17,52.39 185.41,51.14 v2(185.41,49.73) ; R131.1 v2(175.95,50.35)
  IN1 w0.508: v2(166.25,76.33) 166.25,80.13 165.64,80.73 158.49,80.73 156.63,82.59 156.63,83.23 v2(155.25,84.62) ; v2(164.33,69.86) 164.33,69.15 164.84,68.64 170.29,68.64 174.52,64.42 174.52,63 175.09,62.42 176.04,62.42 178.83,59.62 179.33,59.62 v2(181.05,57.9)
  IN2 w0.508: v2(72.67,29.45) 71.32,30.81 70.66,30.81 68.9,32.56 64.54,32.56 62.24,34.87 62.24,35.46 59.62,38.09 58.43,38.09 57.61,38.9 v2(57.61,39.12) 56.14,40.59 53.75,40.59 52.77,41.56 52.77,46.91 50.78,48.91 50.78,53.42 51.83,54.47 v2(51.83,55.18) 52.34,55.18 52.98,55.81 52.98,59.24 52.47,59.75 52.47,62.16 53.23,62.93 v2(53.23,63.69) ; v2(155.25,84.62) 154.08,85.79 108.46,85.79 106.95,84.28 94.52,84.28 92.56,82.32 86.96,82.32 84.06,79.42 75.08,79.42 71.89,76.22 71.89,74.75 67.71,70.57 67.71,69.61 65.63,67.52 63.14,67.52 62.73,67.12 57.3,67.12 56.91,67.5 v2(56.91,68.06) ; v2(164.33,69.86) 164.11,70.08 164.11,74.09 165.13,75.11 165.48,75.11 166.25,75.88 v2(166.25,76.33) ; 24.49,59.82 24.49,62.04 25.13,62.67 25.13,63.65 v2(26.84,65.37)
  IN4 w0.508: v2(56.91,68.06) 56.91,67.37 v2(53.23,63.69) ; v2(72.67,29.45) 72.67,28.01 70.99,26.33 70.99,24.46 v2(71.8,23.65)
  BOTTOM w0.508: v2(26.84,65.37) 26.84,67.4 29.48,70.04 31.64,70.04 32.71,71.11 38.58,71.11 38.93,70.75 43.11,70.75 43.79,71.44 54.1,71.44 56.91,68.62 v2(56.91,68.06) ; 182.64,47.05 182.89,47.05 183.79,47.95 R27115.1 184.66,48.18 185.41,48.93 v2(185.41,49.73) ; 182.64,47.05 182.32,46.73 182.32,44.98 182.82,44.47 v2(183.03,44.47) ; 182.64,47.05 182.64,47.17 181.8,48.01 178.3,48.01 v2(175.95,50.35) ; R1026.2 66.08,24.03 66.46,23.65 v2(71.8,23.65)
  vias: v2(24.43,29.54) v2(24.43,28.95) v2(26.38,20.77) v2(26.97,20.77) v2(27.62,59.73) v4(20.8,58.28) v4(20.8,57.65) v4(21.43,58.94) v4(21.43,58.28) v4(21.43,57.65) v4(22.07,58.91) v4(22.24,56.58) v4(27.3,37.93) v4(27.3,37.3) v4(27.3,36.66) v4(27.93,37.3) v4(27.93,36.66) v4(27.96,37.96)
PP5000_U_R: length 14.1
  TOP w0.203: C258.2 41.21,37.86 40.89,37.53 C356.1 40.89,36.22 40.18,35.51 v2(40.18,35.36) 40.18,35.03 40.1,34.95 U31.10
  IN4 w0.203: v2(40.18,35.36) 39.71,35.83 32.35,35.83 32.05,35.53 v2(32.05,34.44)
  vias: v4(33.17,36.13)
PP5000_U_VCCIO_EXT: length 18.6
  TOP w0.203: C362.1 161.32,72.97 162.36,74.01 U38.9 ; v2(164.86,79.48) R457.1
  TOP w0.508: v2(158.62,72.32) 159.25,71.69 R462.2 160.45,71.72 161.19,72.45 161.19,72.83 C362.1
  IN1 w0.508: v2(158.62,72.32) 159.41,72.32 159.92,72.83 159.92,75.63 161.44,77.15 164.36,77.15 164.86,77.66 v2(164.86,79.48)
