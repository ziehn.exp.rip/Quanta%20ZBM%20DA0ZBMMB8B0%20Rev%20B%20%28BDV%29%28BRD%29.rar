# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): 150.78,45.35 151.37,45.35 151.39,45.34 151.43,45.3 151.4,45.25 151.3,45.18 151.23,45.08 151.23,45.07 151.15,44.99 150.97,44.99 150.46,45.49 149.92,45.49 149.74,45.31 149.63,45.31 149.63,45.39 149.65,45.4 149.71,45.47 149.75,45.54 149.76,45.55 149.93,45.72 150.41,45.72
GND on IN3 (solid shape): 153,46.52 153.02,46.41 152.93,46.35 152.46,46.35 151.99,45.87 151.64,45.87 151.57,45.9 151.5,45.91 151.44,45.9 151.37,45.87 150.99,45.87 150.62,46.25 149.84,46.25 149.84,46.31 149.86,46.35 150.08,46.57 150.28,46.57 150.49,46.36 151.2,46.36 151.49,46.65 151.59,46.55 152.71,46.55 152.84,46.68
GND on IN3 (solid shape): 131.56,35.79 131.62,35.88 131.73,35.86 131.88,35.72 131.88,34.66 132.28,34.25 132.28,34.21 131.84,33.77 131.84,32.75 131.81,32.68 131.73,32.65 131.69,32.65 131.62,32.68 131.58,32.75 131.58,33.28 131.39,33.47 131.39,33.69 131.66,33.95 131.67,33.96 131.86,34.23 131.67,34.51 131.66,34.51 131.56,34.61
GND on IN3 (solid shape): 104.47,39.79 104.44,39.77 104.4,39.74 103.7,39.04 103.62,39.04 103.24,39.42 102.87,39.42 102.54,39.09 102.51,39.11 102.44,39.14 102.37,39.15 100.9,39.15 100.83,39.17 100.77,39.18 100.71,39.17 100.64,39.15 100.57,39.15 100.35,39.37 100.06,39.37 99.96,39.35 99.88,39.29 99.8,39.21 99.71,39.29 99.63,39.35 99.53,39.37 99.35,39.37 99.32,39.37 99.29,39.36 99.21,39.38 99.17,39.46 99.17,39.53 99.06,39.64 99.29,39.87 103.45,39.87 103.47,39.89 104.45,39.89
GND on IN3 (solid shape): 153.18,40.98 153.15,40.91 153.15,40.85 153.15,40.81 153.13,40.73 153.05,40.69 152.52,40.69 152.12,40.29 151.83,40.29 151.5,40.33 151.49,40.34 151.41,40.37 151.33,40.38 151.19,40.34 151.08,40.23 150.65,40.23 150.51,40.37 149.92,40.37 149.81,40.26 149.51,40.26 149.5,40.27 149.5,40.51 149.52,40.54 149.55,40.56 149.72,40.61 149.82,40.75 149.83,40.76 150.05,40.99 150.67,40.99 150.72,41.04 150.95,41.04 151.11,40.88 151.48,40.88 151.55,40.86 151.62,40.85 151.79,40.9 151.89,41.05 151.92,41.07 153.18,41.07
GND on IN3 (solid shape): 102.32,33.12 102.34,33.01 102.24,32.95 101.73,32.95 101.36,32.58 101.36,31.63 101.3,31.54 101.18,31.56 101.03,31.72 101.02,31.73 100.75,31.92 100.47,31.73 100.47,31.72 100.26,31.52 100.18,31.52 100.1,31.59 100.1,32.75 99.86,32.99 99.3,32.99 99.2,33.05 99.23,33.16 99.27,33.21 100.46,33.21 100.5,33.17 100.51,33.15 100.61,33.01 100.78,32.96 100.95,33.01 101.05,33.15 101.06,33.16 101.12,33.23 102.21,33.23
GND on IN3 (solid shape): 98.63,39.78 98.59,39.77 98.52,39.75 98.46,39.7 98.37,39.61 98.31,39.53 98.29,39.43 98.29,39.15 98.25,39.14 98.19,39.11 98.14,39.07 97.94,38.88 97.87,38.85 97.79,38.89 97.56,39 97.32,38.88 97.24,38.84 97.16,38.88 97.07,38.96 96.95,39 96.89,39.03 96.86,39.1 96.86,39.15 97.1,39.38 97.18,39.41 97.25,39.37 97.67,39.29 97.73,39.71 97.71,39.82 97.81,39.87 98.63,39.87
GND on IN3 (solid shape): 137.31,37.03 137.47,36.86 137.47,36.77 137.3,36.77 137.05,36.52 137.05,36.39 137.03,36.32 137.02,36.25 137.05,36.12 137.15,36.01 137.19,35.93 137.15,35.84 137.05,35.74 137.02,35.6 137.02,35.55 136.89,35.13 136.77,34.43 136.74,34.38 136.69,34.36 136.65,34.39 136.6,34.48 136.52,34.55 136.51,34.55 136.26,34.93 136.36,35.42 136.36,35.85 136,36.31 136,36.32 135.89,36.48 135.71,36.55 135.6,36.52 135.51,36.46 135.44,36.43 135.37,36.46 135.32,36.51 135.26,36.51 135.17,36.57 135.18,36.68 135.23,36.75 135.25,36.82 135.26,36.83 135.58,37.15 137.31,37.15
GND on IN3 (solid shape): 102.19,38.33 102.22,38.38 102.27,38.37 102.44,38.19 102.44,38.05 102.42,37.98 102.41,37.91 102.5,37.71 102.7,37.62 102.87,37.67 102.98,37.81 102.98,37.82 103.03,37.86 103.07,37.82 103.08,37.81 103.11,37.74 103.16,37.69 103.19,37.61 103.16,37.54 103.02,37.4 103.02,37.33 102.93,37.3 102.83,37.37 102.71,37.4 102.51,37.31 102.42,37.11 102.42,37.09 102.39,37.01 102.32,36.98 102.06,36.98 101.98,37.03 101.97,37.12 101.99,37.18 101.99,37.23 101.99,37.45 101.98,37.55 101.92,37.64 101.75,37.8 101.67,37.8 101.67,37.86 101.68,37.9 101.68,37.93 101.68,38.04 101.94,38.04 102.19,38.28
GND on IN3 (solid shape): 122.84,33.14 122.87,33.19 122.92,33.18 122.95,33.15 123.96,33.15 124.05,33.09 124.03,32.98 123.68,32.63 123.67,32.62 123.53,32.52 123.48,32.35 123.51,32.21 123.61,32.1 123.66,32.01 123.61,31.93 123.51,31.82 123.47,31.67 123.47,31.66 123.45,31.62 123.41,31.61 123.4,31.61 122.46,31.61 122.46,31.66 122.37,31.86 122.16,31.95 122.1,31.94 122.03,31.92 121.91,31.92 121.82,31.98 121.84,32.09 121.94,32.19 121.97,32.16 122.06,32.11 122.16,32.09 122.23,32.1 122.3,32.12 122.6,32.12 122.62,32.15 122.69,32.18 122.76,32.15 122.86,32.09 122.97,32.07 123.26,32.36 122.97,32.65 122.95,32.65 122.87,32.68 122.84,32.75 122.84,32.96 122.84,32.96
GND on IN3 (solid shape): 135.56,35.73 135.63,35.82 135.74,35.79 135.84,35.67 135.84,35.47 135.71,34.83 136.08,34.27 136.09,34.21 136.11,34.16 136.11,33.89 135.84,33.61 135.84,32.65 136.23,32.26 136.23,32.25 136.34,32.11 136.51,32.06 136.72,32.14 136.8,32.35 136.75,32.51 136.61,32.62 136.6,32.63 136.54,32.68 136.59,32.73 136.6,32.73 136.71,32.8 136.78,32.91 136.79,32.92 137.15,33.28 137.25,34.09 137.25,34.1 137.29,34.21 137.29,34.33 137.28,34.34 137.39,34.95 137.45,34.99 137.49,34.94 137.49,34.69 137.73,34.44 137.87,34.44 137.87,33.27 137.22,32.63 137.21,32.62 137.02,32.34 137.21,32.07 137.25,32.02 137.21,31.97 137.18,31.96 137.14,31.94 137.04,32 136.92,32.02 136.9,32.02 136.78,32 136.68,31.94 136.6,31.98 136.51,31.99 136.42,31.98 136.34,31.94 136.24,32 136.12,32.02 135.82,32.02 135.68,32.22 135.56,32.33 135.56,32.93 135.38,34.21 135.56,34.34 135.56,34.83 135.4,34.99 135.37,35.06 135.4,35.14 135.56,35.3
GND on IN3 (solid shape): 148,40.71 148,40.71 148.24,40.56 148.49,40.69 148.58,40.73 148.66,40.68 148.73,40.61 148.82,40.57 148.83,40.56 148.98,40.42 148.98,40.06 149.29,39.74 149.41,39.74 149.51,39.68 149.49,39.57 149.44,39.52 149.43,39.52 149.34,39.03 149.82,39.15 149.82,39.16 150.05,39.41 150.13,39.44 150.2,39.42 150.5,39.11 150.66,39.11 150.75,39.05 150.73,38.94 150.64,38.85 150.64,38.31 150.58,38.31 150.51,38.35 150.48,38.42 150.29,38.72 149.95,38.61 149.87,38.57 149.78,38.61 149.25,38.41 149.82,38.35 149.87,38.39 149.91,38.35 149.93,38.31 149.93,38.18 149.93,38.16 149.92,38.09 149.86,38.05 149.75,37.99 149.66,37.91 149.62,37.92 149.57,37.92 149.53,37.92 149.48,37.91 149.35,38.02 149.19,38.06 147.87,38.06 147.87,38.25 147.92,38.34 147.93,38.44 147.92,38.54 147.87,38.63 147.87,39.04 147.94,39.24 147.87,39.45 147.87,40.67 147.96,40.75
GND on IN3 (solid shape): outline of 103 points within 94.73,32.95 96.54,39.92
GND on IN3 (solid shape): outline of 426 points within 130.52,31.94 137.2,39.84
GND on IN3 (solid shape): outline of 42454 points within 0.51,0.51 197.69,88.89
GND on IN4 (solid shape): 115.72,81.21 115.72,79.69 115.69,79.67 112.31,79.67 112.16,79.82 112.16,81.21 112.41,81.47 115.46,81.47
GND on IN4 (solid shape): 95.02,51.92 95.02,50.27 94.88,50.13 93.11,50.13 92.46,49.47 91.37,49.47 91.09,49.75 91.09,51.83 91.35,52.1 94.84,52.1
GND on IN4 (solid shape): 11.37,53.89 11.37,53.14 11.32,52.97 11.3,52.8 11.32,52.63 11.37,52.46 11.37,51.6 11.83,51.14 12.91,51.14 13.31,50.74 13.31,50.03 11.31,48.03 9.64,48.03 9.55,48.03 9.45,48.03 9.35,48.03 8.64,48.15 8.02,48.53 4.67,48.53 4.67,48.48 4.73,48.33 4.77,48.17 4.8,48.02 4.82,47.87 4.82,47.78 4.82,47.7 4.82,47.63 4.82,47.56 3.8,47.56 3.81,47.63 3.81,47.7 3.8,47.78 3.8,47.87 3.68,48.22 3.46,48.51 3.46,49.24 3.76,49.54 8.48,49.54 8.85,49.18 9.35,49.04 10.06,49.34 10.36,50.05 10.36,53.97 10.43,54.03 11.23,54.03
GND on IN4 (solid shape): outline of 196 points within 0.51,0.51 197.69,88.89
GND on IN4 (solid shape): outline of 24101 points within 90.5,25.9 161.56,64.66
GND on IN5 (solid shape): outline of 64435 points within 0.51,0.51 197.69,88.89
VCCIO_EXT_LGATE on TOP (solid shape): 162.06,75.4 162.06,74.56 161.45,73.95 161.08,73.95 160.95,74.04 160.79,74.08 160.54,73.98 160.41,73.74 160.41,73.72 159.45,72.76 158.79,72.76 158.66,72.89 158.66,73.41 158.8,73.55 158.95,73.55 160.91,75.51 161.94,75.51
VCCIO_EXT_PHASE on TOP (solid shape): 162.06,76.76 162.03,76.73 161.82,76.73 161.57,76.48 161.55,76.48 161.04,75.97 161,75.93 160.98,75.89 158.94,73.85 150.88,73.85 150.61,74.12 150.61,77.05 150.91,77.36 152.95,77.36 153.59,76.71 159.41,76.71 160.2,77.5 160.2,77.57 160.23,77.6 160.32,77.63 160.4,77.58 160.48,77.49 160.6,77.45 160.9,77.45 161.05,77.51 161.12,77.65 161.13,77.69 161.64,77.69 161.67,77.71 162.06,77.71
VCCIO_EXT_UGATE on TOP (solid shape): 159.38,80.11 159.38,79.57 159.39,79.57 159.39,78.47 159.3,78.38 158.87,78.38 158.61,78.64 158.61,79.34 158.11,79.84 158.11,80.1 158.22,80.2 158.26,80.23 158.26,80.25 158.29,80.28 159.21,80.28
VCCIO_SNS_R_P on IN2 (solid shape): outline of 784 points within 120.87,66.45 140.37,72.81
AUX_LGATE on TOP (solid shape): 57.68,61.02 57.68,60.51 57.93,60.26 57.93,58.86 57.8,58.74 56.15,58.74 56.03,58.86 56.03,59.57 55.52,60.08 55.52,60.54 55.95,60.54 55.95,60.49 55.96,60.43 55.97,60.38 56,60.34 56.03,60.29 56.06,60.25 56.1,60.22 56.15,60.19 56.2,60.17 56.25,60.16 56.3,60.16 56.36,60.16 56.41,60.17 56.46,60.19 56.51,60.22 56.55,60.25 56.58,60.29 56.61,60.34 56.64,60.38 56.65,60.43 56.66,60.49 56.66,60.54 56.65,60.59 56.64,60.64 56.61,60.69 56.58,60.74 56.55,60.78 56.51,60.81 56.46,60.84 56.41,60.85 56.36,60.87 56.3,60.87 56.25,60.87 56.2,60.85 56.15,60.84 56.1,60.81 56.06,60.78 56.03,60.74 56,60.69 55.97,60.64 55.96,60.59 55.95,60.54 55.52,60.54 55.52,61.05 55.82,61.35 57.35,61.35
AUX_SW on TOP (solid shape): 54.88,57.59 55.98,57.59 57.19,57.59 57.57,57.97 64.9,57.97 65.37,57.5 65.37,52.91 64.88,52.42 61.87,52.42 60.56,51.12 56.41,51.12 56.28,51.24 56.28,55.56 56.03,55.81 54.25,55.81 53.74,56.32 53.74,57.21 52.85,58.1 52.85,58.23 52.88,58.25 54.22,58.25
AUX_UGATE on TOP (solid shape): 56.03,55.43 56.03,51.24 55.96,51.17 55.01,51.17 54.76,51.43 54.76,54.29 54.76,54.29 54.76,55.43 54.88,55.56 55.9,55.56
BGATE on BOTTOM (solid shape): 85.87,18.48 85.87,17.46 85.62,17.21 85.24,17.21 84.98,17.46 84.98,18.48 85.11,18.6 85.74,18.6
H1_CC1 on TOP (solid shape): 165.48,17.9 165.48,17.67 164.76,16.95 164.31,16.95 164.24,17.02 164.24,17.54 164.33,17.63 164.7,17.63 165.1,18.04 165.35,18.04
H1_CC2 on TOP (solid shape): 163.98,18.05 164.23,18.05 164.28,18.1 164.68,18.1 164.68,18.1 164.86,18.1 164.88,18.07 164.88,17.97 164.69,17.77 164.2,17.77 163.91,17.49 163.91,16.98 163.88,16.95 163.53,16.95 163.49,16.99 163.49,18.06 163.58,18.15 163.88,18.15
HP_GND_SLEEVE on BOTTOM (solid shape): 19.49,44.72 19.49,44.21 18.94,43.67 17.3,43.67 17.18,43.78 17.18,44.39 17.25,44.46 17.8,44.46 18,44.26 18.37,44.26 18.41,44.25 18.46,44.24 18.5,44.25 18.55,44.26 18.71,44.26 18.96,44.5 18.96,44.73 19.11,44.88 19.33,44.88
HP_RIGHT on TOP (solid shape): 17.04,37.93 18.05,37.93 18.05,37.77 18,37.72 17.04,37.72 17.04,37.7 16.86,37.7 16.79,37.63 16.77,37.63 16.74,37.6 16.72,37.6 16.65,37.62 16.58,37.63 16.33,37.52 16.23,37.27 16.25,37.15 16.31,37.04 16.31,36.47 16.22,36.38 15.69,36.38 15.36,36.05 15.13,36.05 15,36.18 15,36.41 15.61,37.02 15.63,37.04 15.71,37.16 15.74,37.3 15.74,37.47 15.84,37.57 15.87,37.59 15.99,37.66 16.04,37.79 16.04,37.81 16.12,37.88 16.3,37.88 16.35,37.87 16.4,37.87 16.53,37.89 16.63,37.96 17.04,37.96
HP_RING2 on TOP (solid shape): 19.45,47.18 19.8,47.18 19.91,47.07 19.91,46.39 19.61,46.09 19.61,45.28 19.52,45.19 19.03,45.19 18.96,45.26 18.96,47 19.15,47.19 19.44,47.19
HP_SLEEVE on BOTTOM (solid shape): 16.89,46.05 16.89,43.62 16.79,43.51 16.08,43.51 16.08,43.52 15.6,43.52 15.53,43.59 15.53,46.07 15.62,46.16 16.78,46.16
HP_SLEEVE_SENSE on BOTTOM (solid shape): 16.58,43.11 16.58,42.55 15.99,41.96 15.84,41.96 15.68,42.12 15.68,42.89 16.01,43.23 16.46,43.23
IMVP9_LGATE1 on TOP (solid shape): 168.68,49.31 168.68,48 168.58,47.9 167.45,47.9 167.14,48.2 167.14,49.55 167.2,49.61 168.38,49.61
IMVP9_LGATE1 on TOP (solid shape): 174.32,51.96 174.32,50.75 173.92,50.36 173.19,50.36 172.68,50.86 172.68,52.3 172.75,52.37 173.91,52.37
IMVP9_PHASE1 on TOP (solid shape): 167.22,64.92 167.22,64.33 167.21,64.32 167.21,59.92 167.41,59.71 171.14,59.71 171.26,59.59 171.26,58.19 171.64,57.81 173.19,57.81 173.57,57.43 173.57,54.38 173.7,54.26 174.04,54.26 174.1,54.22 174.18,54.2 174.48,54.2 174.53,54.21 174.58,54.22 174.61,54.24 174.71,54.13 174.71,53.62 174.59,53.49 173.57,53.49 172.95,52.88 168.64,52.88 168.24,52.48 168.24,50.45 167.93,50.14 163.34,50.14 163.16,50.32 163.16,57.03 163.16,57.03 163.16,60.01 163.29,60.13 164.15,60.13 164.41,60.39 164.41,60.95 164.33,61.02 163.21,61.02 163.09,61.15 163.09,64.75 163.59,65.25 166.89,65.25
IMVP9_UGATE1 on TOP (solid shape): 173.44,59.59 173.44,58.45 173.19,58.19 171.92,58.19 171.79,58.32 171.79,59.72 171.92,59.84 173.19,59.84
IMVP9_UGATE1 on TOP (solid shape): 176.96,55.06 176.96,55 177,54.96 177,54.89 177.1,54.79 177.1,54.76 177.27,54.76 177.27,54.72 178.02,54.72 178.02,54.52 177.27,54.52 177.27,54.51 176.66,54.51 176.62,54.54 176.56,54.57 176.49,54.64 175.86,54.64 175.73,54.76 175.73,55.14 175.82,55.23 176.78,55.23
IMVP9_UGATE1 on IN2 (solid shape): 173.32,59.72 173.32,57.81 173.19,57.68 172.56,57.68 172.43,57.81 172.43,59.72 172.56,59.84 173.19,59.84
IMVP9_UGATE1 on IN2 (solid shape): 177,55.14 177,54.76 176.87,54.64 174.97,54.64 174.84,54.76 174.84,55.4 174.97,55.53 176.62,55.53
KB_BL_IN on TOP (solid shape): 77.31,14.09 77.31,12.34 77.31,12.08 77.06,11.82 77.06,11.79 77.03,11.72 77.02,11.66 77.06,11.54 77.15,11.44 77.2,11.4 77.33,11.4 77.4,11.34 77.4,11.18 77.35,11.13 76.55,11.13 75.37,12.31 75.37,13.94 75.66,14.23 77.17,14.23
LSPK_N on TOP (solid shape): 27.2,26.48 27.2,24.89 26.91,24.6 26.17,24.6 26.05,24.72 26.05,25.49 26.13,25.57 26.13,26.67 26.19,26.73 26.95,26.73
LSPK_N on BOTTOM (solid shape): 26.96,26.69 26.96,26.18 26.85,26.07 26.85,26.05 26.84,26.04 26.84,25.63 26.84,25.54 26.85,25.49 26.85,25.15 26.68,24.97 26.68,23.86 26.47,23.65 26.47,21.84 26.37,21.74 25.75,21.74 25.68,21.81 25.68,23.61 25.61,23.68 25.61,25.3 25.75,25.44 25.75,26.68 25.8,26.73 26.92,26.73
LSPK_P on TOP (solid shape): 21.35,29.89 21.35,28.9 21.18,28.72 20.4,28.72 20.4,28.76 20.27,28.9 20.27,29.89 20.47,30.08 21.16,30.08
LSPK_P on TOP (solid shape): 25.87,27.41 25.87,25.67 25.56,25.36 24.9,25.36 24.81,25.45 24.81,27.37 24.95,27.51 25.78,27.51
LSPK_P on BOTTOM (solid shape): 25.49,26.68 25.49,25.54 25.36,25.41 25.36,23.79 25.22,23.65 25.22,21.82 25.11,21.72 24.52,21.72 24.43,21.8 24.43,23.63 24.17,23.89 24.17,26.07 24.37,26.27 24.37,26.68 24.42,26.73 25.44,26.73
LSPK_R_N on TOP (solid shape): 26.95,24.15 26.95,23.44 26.66,23.15 24.45,23.15 24.42,23.15 24.04,23.15 24.01,23.15 23.41,23.15 23.21,23.35 22.37,23.35 22.37,23.35 22.23,23.35 22.21,23.37 22.21,23.61 22.25,23.65 23.52,23.65 24.09,24.23 26.87,24.23
LSPK_R_P on TOP (solid shape): 21.37,28.24 21.37,26.65 21,26.29 21,24.98 20.97,24.95 20.72,24.95 20.7,24.98 20.7,26.24 20.24,26.7 20.24,28.22 20.41,28.39 21.22,28.39
PP600_DRAM_U on TOP (solid shape): 180.29,36.29 180.29,35.64 179.94,35.29 177.61,35.29 177.38,35.52 177.38,36.12 177.52,36.25 179.17,36.25 179.4,36.48 180.11,36.48
PP600_DRAM_U on TOP (solid shape): 120.54,42.78 120.54,42.52 120.55,42.52 120.66,42.41 120.66,42.11 120.67,42.08 120.68,42.04 120.68,41.14 120.75,41.07 120.75,41.06 120.83,40.95 120.96,40.91 121.11,40.96 121.18,41.11 121.24,41.2 121.35,41.17 121.58,40.94 121.66,40.89 121.76,40.87 121.77,40.87 121.85,40.84 121.88,40.77 121.88,40.73 121.82,40.68 121.76,40.69 121.62,40.64 121.55,40.52 121.5,40.45 121.42,40.44 121.38,40.45 121.34,40.45 121.13,40.37 121.04,40.16 121.04,40.15 121.02,40.07 120.95,40.04 120.8,39.97 120.74,39.82 120.76,39.73 120.83,39.65 121.07,39.46 121.08,39.44 121.12,39.34 121.19,39.27 121.24,39.18 121.19,39.1 121.1,39 121.07,38.86 121.07,38.85 121.04,38.77 120.97,38.74 120.89,38.73 120.83,38.7 120.6,38.53 120.56,38.53 120.46,38.51 120.37,38.46 120.33,38.43 120.25,38.51 120.25,41.91 120.34,42 120.34,42.78 120.36,42.81 120.52,42.81
PP600_DRAM_U on TOP (solid shape): outline of 7895 points within 90.37,23.7 161.46,49.06
PP600_DRAM_U on BOTTOM (solid shape): 162.24,35.71 176.87,35.71 177.49,36.33 178.67,36.33 178.74,36.26 178.74,35.38 178.31,34.95 161.02,34.95 160.31,35.66 160.31,36.43 160.67,36.78 161.17,36.78
PP600_DRAM_U on IN3 (solid shape): 106.31,35.86 106.41,35.8 106.38,35.69 106.32,35.59 106.3,35.48 106.59,35.19 106.88,35.48 106.86,35.59 106.8,35.69 106.78,35.8 106.87,35.86 107.36,35.86 107.54,35.68 107.54,33.99 107.3,33.75 106.87,33.75 106.91,33.84 106.92,33.94 106.59,34.27 106.26,33.94 106.28,33.84 106.32,33.75 105.96,33.75 105.71,34 105.71,35.66 105.91,35.86
PP600_DRAM_U on IN3 (solid shape): outline of 140 points within 120.24,38.73 122.69,42.26
PP600_DRAM_U on IN5 (solid shape): outline of 168 points within 94.39,33.62 96.42,37.53
PP600_DRAM_U on IN5 (solid shape): outline of 185 points within 120.03,26.44 122.45,30.75
PP600_DRAM_U on IN5 (solid shape): outline of 213 points within 116.03,37.96 118.01,41.94
PP600_DRAM_U on IN5 (solid shape): outline of 269 points within 156.47,38.55 159.35,42.69
PP600_DRAM_U on IN5 (solid shape): outline of 368 points within 143.76,36.78 146.49,43.54
PP600_DRAM_U_R on TOP (solid shape): 180.73,39.92 180.73,39.7 180.43,39.4 180.43,38.44 180.33,38.3 180.29,38.13 180.41,37.83 180.7,37.71 180.72,37.71 180.94,37.49 180.94,37.11 180.81,36.98 179.03,36.98 178.91,37.11 178.64,37.11 178.59,37.12 178.55,37.13 178.45,37.14 178.4,37.14 178.24,37.14 178.14,37.24 178.14,38.23 178.17,38.25 178.23,38.31 178.25,38.39 178.25,38.62 178.62,38.99 178.63,38.99 178.82,39.1 178.93,39.28 178.93,39.3 179.34,39.7 179.4,39.75 179.45,39.8 179.53,39.8 179.7,39.97 180.68,39.97
PP1050_INTERNAL on TOP (solid shape): 107,58.18 107.05,58.17 107.1,58.18 107.16,58.19 107.71,58.19 107.76,58.18 107.81,58.17 107.86,58.18 107.92,58.19 108.47,58.19 108.52,58.18 108.56,58.17 108.63,58.14 108.66,58.07 108.66,58.06 108.7,57.91 108.8,57.8 108.8,57.43 108.67,57.3 106.9,57.3 106.77,57.43 106.77,58.07 106.9,58.19 106.95,58.19
PP1050_OUT_PCH on TOP (solid shape): 69.89,66.81 70,66.59 70.22,66.48 70.51,66.19 70.51,65.53 69.78,64.81 69.26,64.81 69.18,64.85 69.08,64.86 68.99,64.85 68.9,64.81 68.63,64.81 68.54,64.85 68.45,64.86 68.35,64.85 68.26,64.81 67.89,64.81 67.88,64.82 67.88,65.2 68.75,65.2 69.09,65.54 69.09,66.95 69.25,67.11 69.59,67.11
PP1050_OUT_PCH on TOP (solid shape): 115.84,76.64 115.84,74.1 115.63,73.89 115.63,72.49 115.35,72.21 115.33,72.2 114.95,72.2 114.84,72.31 114.84,72.78 114.85,72.81 115.1,73.06 115.11,73.06 115.21,73.13 115.24,73.24 115.24,73.63 115.21,73.66 115.21,73.72 115.2,73.73 115.19,73.75 115.16,73.87 115.08,73.97 115.08,74.17 114.7,74.55 114.7,75.71 114.7,75.73 114.73,75.79 114.74,75.86 114.73,75.93 114.7,75.99 114.7,76 114.7,76.64 114.83,76.77 115.72,76.77
PP1050_OUT_PCH on BOTTOM (solid shape): 115.9,77.02 115.9,75.75 115.6,75.45 114.82,75.45 114.72,75.55 114.72,76.09 114.56,76.25 113.93,76.25 113.66,76.52 113.66,77.22 113.76,77.32 115.6,77.32
PP1050_ST_S on TOP (solid shape): 68.77,66.93 68.77,65.62 68.57,65.43 67.89,65.43 67.85,65.47 67.85,66.13 67.86,66.14 67.86,66.58 68.19,66.91 68.21,66.91 68.35,67.05 68.65,67.05
PP1050_ST_S on TOP (solid shape): 116.98,78.05 116.98,77.7 116.78,77.5 116.78,74.25 116.52,73.99 116.52,73.27 116.53,73.21 116.56,73.15 116.56,73.14 116.56,72.57 116.56,72.55 116.53,72.5 116.52,72.44 116.53,72.38 116.48,72.32 115.84,72.32 115.72,72.45 115.72,73.85 115.97,74.1 115.97,77.11 115.97,77.15 115.97,77.75 115.99,77.81 115.99,77.86 115.99,77.92 115.97,77.98 115.97,78.04 116.1,78.17 116.86,78.17
PP1050_ST_S on BOTTOM (solid shape): 116.99,78.93 116.99,77.66 116.86,77.53 116.1,77.53 115.97,77.66 115.97,77.75 115.97,77.75 115.99,77.86 115.97,77.97 115.97,77.98 115.97,78.93 116.1,79.06 116.86,79.06
PP1050_V1P05EXT on TOP (solid shape): 69.87,38.42 69.87,34.7 69.69,34.52 66.4,34.52 66.31,34.61 66.31,38.42 66.44,38.54 69.74,38.54
PP1050_V1P05EXT on IN2 (solid shape): outline of 1827 points within 69.46,58.02 109.94,73.4
PP1050_V1P05EXT on IN3 (solid shape): outline of 826 points within 67.12,35.43 72.57,59.6
PP1050_VCCIO_EXT on TOP (solid shape): 135.91,80.96 138.9,80.96 139.21,81.27 144.42,81.27 144.87,80.82 144.87,80.76 144.88,80.76 144.88,79.66 144.93,79.61 144.93,79.6 145.01,79.49 145.12,79.41 145.13,79.41 145.6,78.95 146.69,78.95 148.76,76.88 148.76,74.19 148.53,73.96 142.45,73.96 142.11,74.31 140.5,74.31 140.37,74.44 140.37,76.61 140.15,76.82 136.08,76.82 135.93,76.96 135.93,78.52 135.4,79.06 135.37,79.06 135.36,79.06 132.2,79.06 131.97,79.29 131.97,79.44 131.59,79.82 130.7,79.82 130.57,79.94 130.57,81.47 130.83,81.72 135.15,81.72
PP1050_VCCIO_EXT on BOTTOM (solid shape): outline of 2089 points within 116.84,66.45 144.98,83.5
PP1100_DRAM_U on TOP (solid shape): outline of 8391 points within 86.12,26.72 161.87,54.19
PP1100_DRAM_U on BOTTOM (solid shape): outline of 342 points within 110.04,56.41 128.64,59.65
PP1100_DRAM_U on IN1 (solid shape): outline of 611 points within 131.52,26.5 135.82,32.62
PP1100_DRAM_U on IN1 (solid shape): outline of 7774 points within 92.79,23.93 167.78,66.99
PP1100_DRAM_U on IN5 (solid shape): outline of 87 points within 131.37,37.98 135.23,41.86
PP1100_DRAM_U_R on TOP (solid shape): 164.52,45.87 166.46,45.87 166.84,45.49 166.86,45.49 167.21,45.14 167.21,41.17 168.07,40.32 168.07,39.49 168.11,39.45 168.11,36.73 168.87,35.97 168.87,35.21 168.75,35.08 161.38,35.08 161.23,35.23 161.23,39.05 162.99,40.81 162.99,44.46 161.76,45.7 161.76,46.36 162.83,47.44 162.96,47.44
PP1100_PLLOC_S0 on TOP (solid shape): 87.55,35.12 87.55,35.08 87.6,34.92 87.72,34.82 87.73,34.81 87.82,34.72 87.82,33.72 87.44,33.34 85.65,33.34 85.38,33.61 85.38,34.68 85.92,35.21 87.47,35.21
PP1100_PLLOC_S0 on TOP (solid shape): 108.69,57.03 108.68,56.97 108.68,56.94 108.71,56.81 108.8,56.72 108.8,56.49 108.68,56.28 108.8,56.06 108.8,55.83 108.73,55.77 108.69,55.69 108.68,55.65 108.26,55.65 108.25,55.69 108.16,55.81 108.02,55.86 107.99,55.86 107.91,55.88 107.88,55.95 107.83,56.12 107.69,56.24 107.66,56.25 107.66,56.92 107.91,57.18 108.55,57.18
PP1100_PLLOC_S0 on BOTTOM (solid shape): 108.34,56.89 108.42,56.88 108.5,56.89 108.6,56.92 108.67,56.92 108.8,56.8 108.8,55.91 108.56,55.67 108.5,55.68 108.47,55.68 108.4,55.67 108.32,55.65 108.17,55.65 107.95,55.87 107.96,55.95 107.95,56.01 107.94,56.07 107.85,56.15 107.81,56.2 107.74,56.27 107.74,56.75 107.91,56.92 108.24,56.92
PP1100_PLLOC_S0 on IN3 (solid shape): outline of 1631 points within 85.41,33.43 108.86,57.93
PP1800_A on TOP (solid shape): 185,36.22 185,35.84 184.92,35.76 184.88,35.76 184.8,35.75 184.73,35.71 184.37,35.71 184.24,35.59 184.24,35.08 183.99,34.82 183.1,34.82 182.84,35.08 182.84,35.59 182.97,35.71 183.35,35.71 183.88,36.24 183.91,36.23 184.14,36.22 184.34,36.35 184.87,36.35
PP1800_A on TOP (solid shape): outline of 370 points within 75.84,35.79 82.42,57.57
PP1800_A on BOTTOM (solid shape): 191.54,82.69 191.54,81.89 191.44,81.79 190.45,81.79 190.25,81.6 190.25,80.34 189.03,79.12 188.47,79.12 188.37,79.22 188.37,79.91 188.57,80.11 188.57,81.4 189.95,82.78 191.44,82.78
PP1800_A on BOTTOM (solid shape): 168.29,76.26 168.29,75.47 168.29,75.36 168.27,75.3 168.26,75.25 168.27,75.19 168.29,75.13 168.29,75.02 168.29,74.48 168.37,74.41 168.37,73.59 168.38,73.48 168.42,73.38 168.43,73.37 168.43,73.21 168.17,73.21 168.01,73.37 168.01,73.46 167.97,73.55 167.88,73.58 167.8,73.58 167.7,73.68 167.7,74.23 167.71,74.28 167.71,74.35 167.66,74.55 167.53,74.71 167.53,75.12 167.02,75.63 167.02,76.13 167.53,76.64 167.91,76.64
PP1800_A on BOTTOM (solid shape): outline of 265 points within 64.84,54.79 76.93,71.89
PP1800_A on IN2 (solid shape): 73.16,71.79 73.16,71.1 72.37,70.3 71.28,70.3 71.18,70.4 71.18,70.8 72.47,72.09 72.87,72.09
PP1800_A on IN4 (solid shape): 177.08,77.63 177.08,76.94 176.09,75.95 175.2,75.95 175,76.15 175,77.63 175.3,77.93 176.78,77.93
PP1800_A_R on TOP (solid shape): 75.78,35.36 79.57,35.36 79.85,35.08 79.85,30.93 79.54,30.62 73.97,30.62 73.84,30.75 73.84,36.03 74.07,36.26 74.89,36.26
PP1800_CLKLDO on TOP (solid shape): 96.32,75.19 99.57,75.19 101.51,75.19 101.91,74.8 101.91,73.62 101.93,73.6 101.81,73.48 101.73,73.37 101.71,73.27 101.77,73.11 101.91,73.02 101.94,73.01 101.94,72.81 101.89,72.73 101.87,72.6 101.75,72.48 101.71,72.45 101.67,72.42 101.18,72.42 101.07,72.52 101.1,72.63 101.06,72.77 100.95,72.87 100.93,72.88 100.93,73.31 100.92,73.32 100.85,73.46 100.72,73.53 100.7,73.53 100.69,73.55 99.08,73.55 98.76,73.87 95.54,73.87 95.45,73.91 95.45,74.01 95.51,74.11 95.54,74.23 95.22,74.55 94.9,74.23 94.9,74.15 94.91,74.08 94.93,74.02 94.93,73.92 94.84,73.87 92.77,73.87 92.61,74.03 92.61,75.1 92.7,75.19 93.06,75.19 93.07,75.19 93.35,75.19 93.36,75.19 94.03,75.19 94.04,75.19 95.57,75.19 95.81,75.42 96.08,75.42
PP1800_DRAM_U on TOP (solid shape): 149.61,32.27 149.61,31.68 149.35,31.42 149.35,30.42 149.15,30.22 148.34,30.22 148,30.55 148,31.96 148.67,32.63 149.25,32.63
PP1800_DRAM_U on IN1 (solid shape): outline of 99 points within 108.14,27.41 117.89,32.72
PP1800_DRAM_U on IN3 (solid shape): outline of 5823 points within 96.58,25.15 160.47,48.35
PP1800_DRAM_U on IN5 (solid shape): outline of 965 points within 130.72,33.27 138.74,38.4
PP1800_DRAM_U on IN5 (solid shape): outline of 1907 points within 116.13,29.84 124.5,37.9
PP1800_DRAM_U on IN5 (solid shape): outline of 2664 points within 147.25,35.36 155.8,47.62
PP1800_DRAM_U on IN5 (solid shape): outline of 3231 points within 97.03,28.28 109.91,40.46
PP1800_HP on TOP (solid shape): 18.05,37.07 18.05,36.88 17.95,36.78 17.95,36.23 17.95,36.23 17.95,35.81 17.06,34.92 17.06,34.48 17,34.42 16.58,34.42 16.53,34.47 16.53,34.94 16.86,35.28 17.07,35.28 17.18,35.38 17.18,35.83 17.35,35.96 17.42,36.17 17.32,36.41 17.09,36.52 17.09,37.07 17.11,37.1 18.03,37.1
PP1800_HP_IO on TOP (solid shape): 22.55,36.54 22.55,35.9 23.26,35.19 23.82,35.19 24.07,34.94 24.07,34.4 23.89,34.22 23.28,34.22 23.18,34.33 22.91,34.33 22.87,34.36 22.81,34.37 22.43,34.37 22.41,34.37 22.38,34.36 22.37,34.38 22.37,34.62 22.31,34.68 22.31,35.21 21.83,35.68 21.83,36.59 21.91,36.67 22.42,36.67
PP1800_LSPK_A on TOP (solid shape): 23.64,21.39 23.69,21.31 23.77,21.28 23.85,21.28 24,21.13 24,20.6 23.51,20.1 23.51,19.61 23.28,19.39 23.04,19.39 22.94,19.49 22.94,20.4 23.33,20.79 23.33,21.28 23.25,21.35 22.27,21.35 22.23,21.4 22.23,21.62 22.26,21.65 23.39,21.65
PP1800_LSPK_A on TOP (solid shape): 20,20.59 20,19.14 20.06,19.08 20.12,19 20.2,18.94 20.33,18.81 20.67,18.81 20.79,18.73 20.93,18.69 21,18.7 21.04,18.66 21.04,17.87 21.03,17.86 21.03,17.5 21.01,17.48 19.69,17.48 19.58,17.59 19.58,18.86 19.7,18.98 19.7,20.63 19.7,20.64 19.96,20.64
PP1800_LSPK_A on IN2 (solid shape): 23.6,20.35 23.6,19.2 23.43,19.03 23.35,19 23.28,19.04 23.16,19.15 23.01,19.19 22.77,19.09 22.67,18.86 22.7,18.73 22.78,18.62 22.81,18.54 22.78,18.47 22.72,18.39 22.68,18.29 22.68,18.28 21.86,17.46 19.7,17.46 19.58,17.59 19.58,18.35 20.08,18.86 20.66,18.86 20.78,18.76 20.93,18.72 21.17,18.82 21.26,19.05 21.25,19.16 21.19,19.26 21.19,19.26 21.17,19.31 22.5,20.64 23.31,20.64
PP1800_RSPK_A on TOP (solid shape): 24.18,11.18 24.18,9.82 24.4,9.6 24.4,9.18 24.33,9.11 23.9,9.11 23.62,8.82 22.19,8.82 22.09,8.93 22.09,9.18 22.12,9.21 23.29,9.21 23.33,9.21 23.55,9.42 23.71,9.42 23.88,9.59 23.88,9.78 23.89,9.86 23.88,9.94 23.88,11.21 24.15,11.21
PP1800_RSPK_A on TOP (solid shape): 27.42,12.23 27.61,12.23 28.29,11.56 28.29,11.54 28.37,11.46 28.41,11.38 28.49,11.35 28.53,11.35 28.71,11.17 28.71,10.73 28.68,10.71 28,10.71 27.89,10.81 27.91,10.85 27.93,10.91 27.93,10.98 27.92,11.1 27.86,11.2 27.86,11.37 27.86,11.38 27.86,11.48 27.41,11.93 26.45,11.93 26.4,11.97 26.4,12.2 26.44,12.23 27.41,12.23
PP1800_SOC_A on TOP (solid shape): outline of 301 points within 79.03,57.98 96.41,73.7
PP1800_SOC_A on IN2 (solid shape): outline of 2257 points within 80.64,55.04 107.84,63.43
PP1800A_HP on TOP (solid shape): 17.16,46.98 17.23,46.91 17.23,44.08 17.29,44.02 17.29,43.5 17.29,43.49 17.29,42.96 17.86,42.39 17.95,42.32 18.06,42.28 18.08,42.28 18.36,41.99 18.38,41.93 18.38,41.42 18.39,41.33 18.43,41.24 18.44,41.23 18.44,41.06 18.36,40.98 17.98,40.98 17.89,41.07 17.89,41.09 17.51,41.46 17.5,41.46 17.34,41.62 17.34,41.63 17.27,41.82 17.12,41.94 17.09,41.95 17.09,42.11 17.1,42.13 17.1,42.15 17.1,42.36 17.07,42.44 16.99,42.48 16.91,42.56 16.65,42.56 16.51,42.71 16.51,43.42 16.56,43.46 16.56,43.91 16.38,44.08 16.38,45.66 16.4,45.68 16.4,46.96 16.6,47.16 16.97,47.16
PP3000_RTC on BOTTOM (solid shape): 103.9,51.59 103.9,51.08 103.77,50.95 102.5,50.95 102.37,51.08 102.37,51.59 102.67,51.88 102.74,51.92 102.8,51.97 103.52,51.97
PP3000_RTC on IN4 (solid shape): outline of 87 points within 90.97,43.21 103.19,52.1
PP3300_A on TOP (solid shape): 46.63,66.23 46.63,65.09 46.5,64.96 45.48,64.96 45.36,65.09 45.36,66.23 45.48,66.36 46.5,66.36
PP3300_A on TOP (solid shape): 26.43,42.61 26.43,41.26 26.16,40.98 25.76,40.98 25.67,41.07 25.67,41.1 25.68,41.14 25.69,41.17 25.69,41.55 25.68,41.59 25.67,41.62 25.67,41.73 25.8,41.86 25.8,42.66 25.95,42.81 26.23,42.81
PP3300_A on TOP (solid shape): 184.37,45.62 184.37,45.05 184.76,44.65 184.76,44.21 185.38,43.59 185.38,42.15 185.3,42.06 185.02,42.06 184.8,42.28 184.8,42.5 184.37,42.94 183.76,42.94 183.59,43.11 183.59,44.11 183.58,44.12 183.58,44.61 183.48,44.72 183.48,45.49 183.73,45.75 184.24,45.75
PP3300_A on TOP (solid shape): 36.93,57.53 36.93,57.08 36.62,56.76 36.35,56.76 35.89,56.31 35.84,56.28 35.81,56.23 35.7,56.12 35.7,55.69 35.45,55.43 34.65,55.43 34.51,55.58 34.51,57.48 34.62,57.59 36.87,57.59
PP3300_A on IN1 (solid shape): 26.82,43.24 26.82,41.46 26.69,41.34 25.93,41.34 25.8,41.46 25.8,43.11 26.05,43.37 26.69,43.37
PP3300_A on IN1 (solid shape): 36.98,57.47 36.98,56.07 36.47,55.56 36.21,55.56 35.71,56.07 35.71,57.47 35.83,57.59 36.85,57.59
PP3300_A on IN2 (solid shape): 46.33,66.34 46.33,65.96 45.16,64.79 44.51,64.79 44.36,64.95 44.36,65.5 45.34,66.48 46.18,66.48
PP3300_A on IN2 (solid shape): 36.98,58.74 36.98,57.12 36.81,56.96 35.98,56.96 35.73,57.21 35.73,57.59 35.95,57.81 35.95,58.86 36.09,58.99 36.72,58.99
PP3300_A on IN4 (solid shape): 36.98,57.47 36.98,56.96 36.7,56.69 36.32,56.69 35.83,57.17 35.83,57.46 35.96,57.59 36.85,57.59
PP3300_A_R on TOP (solid shape): 37.05,54.73 37.05,53.86 36.92,53.58 37.05,53.3 37.11,53.24 37.11,52.76 37.11,52.14 37.06,52.1 36.96,52.1 36.91,52.15 36.91,52.86 36.71,52.86 36.71,52.16 36.65,52.1 36.44,52.1 36.3,52.25 35.29,52.25 35.11,52.43 34.63,52.43 33.78,53.27 31.88,53.27 31.24,53.91 30.44,53.91 30.24,54.11 30.24,54.86 30.43,55.04 36.73,55.04
PP3300_AP_FLASH on TOP (solid shape): 171.41,31.36 171.41,30.99 171.23,30.81 171.22,30.81 171.17,30.78 171.13,30.73 171.13,30.71 171.11,30.69 171.06,30.69 171.06,29.67 170.76,29.67 170.76,30.69 170.73,30.69 170.68,30.75 170.65,30.78 170.62,30.81 170.62,31.59 170.71,31.69 171.08,31.69
PP3300_CAMERA_USER on TOP (solid shape): 47.77,65.21 47.77,63.18 47.52,62.93 46.88,62.93 46.75,63.05 46.75,65.34 46.88,65.47 47.52,65.47
PP3300_CAMERA_USER on BOTTOM (solid shape): 48.07,63.82 48.07,63.19 48.05,63.12 48.05,63.05 48.05,62.99 48.07,62.92 48.07,62.88 48.41,62.55 48.41,62.25 48.4,62.25 48.4,60.97 48.1,60.97 48.1,62.25 47.9,62.25 47.9,60.97 47.64,60.97 47.64,62.27 47.49,62.42 46.86,62.42 46.75,62.52 46.75,63.93 46.83,64 47.89,64
PP3300_DISPLAY_S0 on TOP (solid shape): 40.4,56.93 40.4,55.12 40.3,55.02 39.52,55.02 39.26,55.27 39.26,57.14 39.36,57.24 40.1,57.24
PP3300_DISPLAY_S0 on BOTTOM (solid shape): 54.9,60.95 55.1,60.95 55.1,62.24 55.4,62.24 55.4,60.95 55.6,60.95 55.6,62.24 55.9,62.24 55.9,60.84 55.77,60.72 55.77,58.61 55.64,58.48 53.89,58.48 53.8,58.57 53.8,59.16 53.85,59.17 53.92,59.17 54.24,59.37 54.2,59.74 54.2,60.44 54.6,60.84 54.6,62.24 54.9,62.24
PP3300_DISPLAY_S0 on IN4 (solid shape): outline of 417 points within 39.11,54.54 55.64,60.26
PP3300_EC_G on TOP (solid shape): 146.87,23.52 146.87,22.28 146.55,21.96 146.55,21.51 146.54,21.5 146.51,21.46 146.5,21.41 146.5,21.03 146.51,20.98 146.54,20.94 146.57,20.86 146.54,20.79 146.51,20.75 146.5,20.7 146.5,20.31 146.46,20.3 146.24,20.19 146.15,19.95 146.25,19.7 146.5,19.59 146.59,19.61 146.68,19.64 146.78,19.64 146.83,19.55 146.83,17.77 146.6,17.77 145.36,19.01 145.36,20.13 145.4,20.13 145.61,20.26 145.69,20.48 145.67,20.6 145.61,20.7 145.59,20.78 145.63,20.85 145.75,20.98 145.79,21.14 145.75,21.3 145.64,21.43 145.62,21.45 145.62,21.49 145.63,21.51 145.69,21.61 145.71,21.73 145.69,21.85 145.63,21.96 145.61,21.99 145.36,22.24 145.36,23.02 145.38,23.05 145.93,23.05 145.98,23.1 145.98,23.47 146.11,23.59 146.79,23.59
PP3300_G on TOP (solid shape): 6.74,13.71 6.74,13.45 5.64,12.34 3.23,12.34 3.13,12.44 3.13,12.99 3.19,13.04 5.53,13.04 6.33,13.85 6.6,13.85
PP3300_G on TOP (solid shape): 18.46,30.47 18.46,29.97 18.39,29.91 17.74,29.91 17.55,29.71 17.55,29.33 17.45,29.22 17.2,29.22 16.87,29.55 16.87,30.41 17,30.54 18.39,30.54
PP3300_G on TOP (solid shape): 26.43,45.39 26.43,43.75 26.18,43.5 26.03,43.5 25.8,43.5 25.69,43.61 25.69,43.94 25.68,43.97 25.67,44 25.8,44.13 25.8,45.42 25.91,45.53 26.29,45.53
PP3300_G on TOP (solid shape): 179.41,29.63 179.48,29.53 179.58,29.46 180.36,28.68 180.36,27.64 180.29,27.57 177.69,27.57 177.44,27.83 177.44,29.1 177.06,29.48 176.55,29.48 176.46,29.57 176.46,30.02 176.55,30.11 178.93,30.11
PP3300_G on TOP (solid shape): 164.72,31.58 164.72,30.55 164.72,30.54 164.72,30.04 164.33,29.65 164.1,29.65 163.09,28.64 163.09,28.6 162.9,28.42 162.9,27.88 162.83,27.8 162.58,27.8 162.58,29.02 162.71,29.02 163.09,29.4 163.09,30.29 163.34,30.54 163.85,30.54 164.23,30.92 164.23,31.43 164.41,31.61 164.69,31.61
PP3300_G on TOP (solid shape): 35.08,52.05 35.08,50.35 35.37,50.06 35.92,50.06 36.19,50.33 36.19,50.64 36.36,50.81 36.68,50.81 36.71,50.78 36.71,50.06 36.91,50.06 36.91,50.8 36.92,50.81 37.07,50.81 37.11,50.78 37.11,50.6 37.1,50.59 37.1,50.46 37.1,49.89 36.94,49.74 36.88,49.52 37.3,49.1 37.72,49.52 37.72,49.57 37.72,50.46 37.72,50.59 37.71,50.6 37.71,50.78 37.74,50.81 37.86,50.81 37.91,50.76 37.91,50.6 37.9,50.59 37.9,50.46 37.9,49.57 37.9,49.52 38.32,49.1 38.74,49.52 38.68,49.74 38.52,49.89 38.52,50.46 38.52,50.59 38.51,50.6 38.51,50.78 38.54,50.81 38.68,50.81 38.71,50.78 38.71,50.06 38.91,50.06 38.91,50.77 38.95,50.81 39.14,50.81 39.28,50.95 40.48,50.95 40.6,50.83 40.6,48.31 40.59,48.3 40.59,48.13 40.5,48.05 40.49,48.04 40.24,47.79 40.12,47.79 39.97,47.64 32.05,47.64 31.95,47.73 31.95,48.59 32.66,49.29 32.66,49.3 32.77,49.42 32.77,51.94 32.99,52.16 34.97,52.16
PP3300_G on BOTTOM (solid shape): 55.77,21.91 55.77,20.95 56.05,20.67 56.05,20.15 56.03,20.13 55.39,20.13 54.88,20.64 54.88,21.83 55.14,22.09 55.59,22.09
PP3300_G on BOTTOM (solid shape): 164.83,30.43 164.93,30.43 165.02,30.34 165.02,29.81 164.69,29.48 163.39,29.48 163.34,29.53 163.34,30.36 163.42,30.44 164.81,30.44
PP3300_G on IN2 (solid shape): 40.28,49.97 40.28,49.46 40.15,49.34 39.26,49.34 39.13,49.46 39.13,49.85 39.64,50.35 39.9,50.35
PP3300_G on IN3 (solid shape): outline of 3649 points within 38.88,13.62 179.64,49.97
PP3300_G_R on TOP (solid shape): 33.49,46.73 33.49,38.28 33.33,38.13 29.97,38.13 29.34,38.76 29.34,46.07 30.16,46.89 33.33,46.89
PP3300_H1_G on BOTTOM (solid shape): 163.54,24.55 163.54,24.22 163.47,24.14 163.14,24.14 163.11,24.13 162.98,24.04 162.89,23.9 162.88,23.89 162.52,23.89 162.1,23.47 161.88,23.47 161.78,23.57 161.78,23.89 162.24,24.34 162.25,24.34 162.35,24.42 162.43,24.52 162.43,24.53 162.47,24.57 162.98,24.57 163.06,24.65 163.44,24.65
PP3300_HP_MIC on TOP (solid shape): 25.41,41.71 25.41,41.61 25.4,41.58 25.4,41.55 25.4,41.19 24.05,41.19 24.01,41.16 23.98,41.13 23.95,41.1 23.93,41.08 23.43,40.58 22.73,40.58 22.63,40.57 22.54,40.52 22.25,40.52 22.17,40.6 22.17,40.83 22.18,40.84 22.2,40.88 22.2,40.93 22.2,41.02 22.29,41.11 22.68,41.11 23.44,41.86 25.26,41.86
PP3300_HP_VBAT on TOP (solid shape): 24.73,44.84 24.86,44.68 25.06,44.61 25.1,44.61 25.14,44.62 25.22,44.6 25.26,44.52 25.26,44.07 25.4,43.92 25.4,43.56 25.41,43.51 25.33,43.44 25.01,43.44 24.99,43.42 24.98,43.41 24.88,43.39 24.8,43.33 24.79,43.32 24.67,43.32 24.66,43.33 24.45,43.39 24.24,43.33 24.22,43.32 23.34,42.43 23.34,42.12 22.58,41.36 22.19,41.36 22.01,41.18 21.9,41.16 21.83,41.25 21.83,41.96 22.74,42.87 22.74,43.31 22.92,43.31 23.07,43.46 23.14,43.45 23.18,43.44 23.45,43.56 23.56,43.83 23.55,43.94 23.49,44.05 23.47,44.08 23.65,44.26 23.67,44.26 23.83,44.33 23.89,44.49 23.89,44.68 24.09,44.87 24.72,44.87
PP3300_PANEL_S0 on TOP (solid shape): 40.51,54.34 40.51,52.3 40.32,52.11 38.98,52.11 38.91,52.18 38.91,52.86 38.71,52.86 38.71,52.15 38.67,52.11 38.54,52.11 38.51,52.14 38.51,52.99 38.5,52.99 38.5,53.82 38.51,53.83 38.54,53.88 38.55,53.93 38.55,54.34 38.72,54.51 40.34,54.51
PP3300_SD_U on TOP (solid shape): 15.97,27.31 16.33,27.31 16.35,27.33 17.27,27.33 17.42,27.18 17.42,26.63 17.34,26.55 16.04,26.55 15.96,26.62 15.86,26.65 15.56,26.65 15.4,26.58 15.33,26.42 15.33,26.31 15.16,26.14 14.36,26.14 13.91,25.69 13.67,25.69 13.62,25.65 12.63,25.65 12.57,25.71 12.57,26.18 12.64,26.25 13.58,26.25 14.21,26.88 14.76,26.88 15.21,27.33 15.95,27.33
PP3300_SD_U_R on TOP (solid shape): 18.45,28.58 18.45,27.93 18.39,27.87 16.62,27.87 16.58,27.91 16.58,28.56 16.66,28.64 18.39,28.64
PP3300_SOC_A on TOP (solid shape): 39.13,57.21 39.13,55.56 39.01,55.43 38.7,55.43 38.57,55.56 38.39,55.6 38.22,55.56 38.09,55.43 35.96,55.43 35.83,55.56 35.83,56.07 36.39,56.63 36.72,56.63 37.43,57.34 39.01,57.34
PP3300_SOC_A on BOTTOM (solid shape): 108.64,61.24 108.64,61.12 108.63,61.11 108.6,60.96 108.63,60.81 108.64,60.8 108.64,60.47 108.56,60.24 108.64,60 108.64,59.75 108.6,59.68 108.57,59.59 108.22,59.25 107.97,59.25 107.93,59.21 107.91,59.21 107.79,59.08 107.79,59.06 107.75,59.02 107.75,58.66 107.61,58.52 106.59,58.52 106.52,58.6 106.52,58.85 106.52,58.99 106.52,59.62 106.52,59.63 106.55,59.72 106.56,59.82 106.56,59.89 106.54,59.96 106.53,59.98 106.53,60.12 106.96,60.12 107.05,60.16 107.09,60.24 107.11,60.28 107.12,60.33 107.4,60.61 107.66,60.61 107.66,60.61 107.77,60.61 107.82,60.66 107.87,60.65 108.07,60.65 108.16,60.69 108.2,60.78 108.2,61.18 108.32,61.3 108.58,61.3
PP3300_SOC_A on BOTTOM (solid shape): outline of 157 points within 94.84,44.23 101.2,46.59
PP3300_SOC_A on IN3 (solid shape): outline of 9042 points within 36.59,55.38 110,70.78
PP3300_SOC_A on IN4 (solid shape): outline of 1183 points within 100.03,45.46 109.98,60.61
PP3300_SSD_A on TOP (solid shape): 32.5,56.84 32.5,55.63 32.38,55.5 30.5,55.5 30.33,55.67 30.33,56.86 30.51,57.03 32.31,57.03
PP3300_SSD_A on TOP (solid shape): 65.67,46.99 65.67,46.78 65.79,46.66 66.17,46.66 66.24,46.58 66.24,46.29 66.2,46.25 64.92,46.25 64.82,46.35 64.82,46.51 64.88,46.57 65.13,46.57 65.31,46.75 65.31,46.97 65.41,47.07 65.59,47.07
PP3300_SSD_A on TOP (solid shape): 67.21,45.16 67.42,45.16 67.62,44.96 67.62,44.82 67.51,44.71 67.26,44.71 67.13,44.59 67.13,44.38 67.06,44.31 66.91,44.31 66.78,44.45 66.78,44.92 66.45,45.25 66.45,45.45 66.63,45.63 66.74,45.63
PP3300_SSD_A on BOTTOM (solid shape): outline of 145 points within 30.05,53.15 41.17,56.98
PP3300_SSD_A on BOTTOM (solid shape): outline of 165 points within 64.46,44.4 67.81,47.05
PP3300_SSD_A on IN4 (solid shape): 42.42,54.57 42.42,53.42 42.26,53.26 40.8,53.26 40.51,53.55 40.51,54.57 40.81,54.87 42.12,54.87
PP3300_SSD_A on IN4 (solid shape): outline of 185 points within 59.99,44.01 67.2,47.24
PP3300_THRM on TOP (solid shape): 98.35,25.03 98.35,23.97 98.21,23.82 97.8,23.82 97.08,23.1 96.88,23.1 96.77,23.2 96.77,25.07 96.96,25.26 98.12,25.26
PP3300_THRM_R on TOP (solid shape): 99.32,24.48 99.32,24.17 99.56,23.93 101.3,23.93 101.39,23.84 101.39,23.38 101.26,23.25 99.66,23.25 99.37,22.96 98.81,22.96 98.56,23.21 98.56,24.46 98.65,24.55 99.25,24.55
PP3300_USB_C0_G on BOTTOM (solid shape): 30.46,68.17 30.46,62.11 30.76,61.82 30.76,61.82 32.82,61.82 33.04,62.04 33.04,66.1 33.1,66.17 33.86,66.17 33.98,66.05 33.98,64.81 33.97,64.81 33.95,64.68 33.97,64.55 33.98,64.54 33.98,62.43 33.97,62.42 33.95,62.29 33.97,62.17 33.98,62.16 33.98,61.17 33.95,61.11 33.88,61.08 32.81,61.08 32.36,60.63 32.36,60.61 32.33,60.58 32.33,60.35 32.26,60.27 32.26,59.43 32.33,59.35 32.33,59.07 32.3,59.03 31.24,59.03 31.24,59.02 31,59.02 30.89,59.09 30.76,59.11 30.64,59.1 30.54,59.04 30.51,59.02 30.31,59.21 30.31,61.22 30.18,61.35 29.36,61.35 29.12,61.59 29.12,61.9 29.1,61.93 29.1,66.36 28.76,66.7 28.76,68.19 28.95,68.39 30.24,68.39
PP3300_WLAN_A on TOP (solid shape): 33.04,12.51 33.04,10.22 32.91,10.09 32.15,10.09 31.9,10.35 31.9,12.51 32.02,12.63 32.91,12.63
PP3300_WLAN_A on TOP (solid shape): 43.21,15.33 43.21,15.13 43.41,14.93 44.3,14.93 44.6,14.63 44.6,9.91 44.5,9.81 42.68,9.81 42.61,9.88 42.61,15.42 42.72,15.53 43.01,15.53
PP3300_WLAN_A on TOP (solid shape): 34.36,57.42 34.36,55.64 34.16,55.43 32.78,55.43 32.66,55.56 32.66,57.67 32.76,57.77 34.01,57.77
PP3300_WLAN_A on BOTTOM (solid shape): 32.89,11.93 33.75,11.93 33.84,11.85 33.84,11.2 33.74,11.11 32.94,11.11 32.44,10.6 31.9,10.6 31.77,10.73 31.77,12.25 31.9,12.38 32.44,12.38
PP3300_WLAN_A on BOTTOM (solid shape): 44.28,14.84 44.28,12.03 44.39,11.91 45.23,11.91 45.28,11.87 45.28,11.13 45.21,11.05 44.37,11.05 43.69,10.37 42.68,10.37 42.44,10.61 42.44,13.2 42.59,13.35 43.24,13.35 43.39,13.5 43.42,13.55 43.43,13.6 43.43,13.9 43.42,13.95 43.39,14 43.3,14.09 42.71,14.09 42.67,14.13 42.67,14.9 42.71,14.94 44.18,14.94
PP3300_WLAN_A on IN2 (solid shape): outline of 668 points within 29.97,10.4 39.98,57.92
PP3300_WLAN_A on IN4 (solid shape): outline of 583 points within 31.66,9.78 44.34,14.93
PP5000_LSPK_U on TOP (solid shape): 15.23,22.21 15.23,20.71 15.13,20.61 14.27,20.61 14.06,20.81 14.06,22.21 14.17,22.31 15.13,22.31
PP5000_LSPK_U on TOP (solid shape): 22.84,29.43 22.84,26.96 23.62,26.18 23.62,24.25 23.62,24.21 23.61,24.17 23.62,24.12 23.62,24.08 23.62,24.05 23.43,23.86 22.25,23.86 22.23,23.88 22.23,24.09 22.29,24.15 23.2,24.15 23.2,24.35 22.29,24.35 22.21,24.43 22.21,26.23 21.75,26.69 21.75,29.36 22.03,29.63 22.64,29.63
PP5000_LSPK_U on BOTTOM (solid shape): 15.51,22.16 15.51,21.27 15.39,21.14 14.24,21.14 13.99,21.4 13.99,22.16 14.12,22.29 15.39,22.29
PP5000_LSPK_U on BOTTOM (solid shape): 22.88,25.72 22.88,24.83 22.75,24.7 21.61,24.7 21.35,24.95 21.35,25.72 21.53,25.89 21.63,25.91 21.73,25.97 22.62,25.97
PP5000_RSPK_U on TOP (solid shape): 28.47,20.3 28.47,15.13 27.77,14.44 26.54,14.44 26.43,14.54 26.43,14.74 27.38,14.74 27.38,14.93 26.43,14.93 26.43,15.81 26.69,16.06 27.13,16.06 27.4,16.34 27.4,17.41 27.4,17.41 27.4,20.38 27.5,20.48 28.29,20.48
PP5000_RSPK_U on BOTTOM (solid shape): 28.72,16.7 28.72,14.92 28.59,14.79 27.83,14.79 27.7,14.92 27.7,16.57 27.96,16.83 28.59,16.83
PP5000_RSPK_U on BOTTOM (solid shape): outline of 100 points within 19.55,10.65 22.07,15.35
PP5000_U on TOP (solid shape): 54.25,63.94 54.25,62.16 54.19,62.11 53.03,62.11 52.85,62.29 52.85,63.94 52.98,64.07 54.12,64.07
PP5000_U on TOP (solid shape): 24.68,29.64 24.68,28.85 24.54,28.72 23.24,28.72 23.14,28.82 23.14,29.69 23.24,29.79 24.52,29.79
PP5000_U on TOP (solid shape): 27.2,20.97 27.2,20.54 27.14,20.48 27.14,19.63 27.1,19.58 26.31,19.58 26.11,19.78 26.11,20.87 26.41,21.17 27,21.17
PP5000_U on TOP (solid shape): 29.34,38.17 29.34,36.39 29.28,36.33 27.2,36.33 27.02,36.51 27.02,38.14 27.2,38.33 29.19,38.33
PP5000_U on TOP (solid shape): 27.86,59.8 27.86,59.42 27.45,59.02 27.25,59.02 27.11,59.16 27.12,59.23 27.13,59.27 27.11,59.38 27.05,59.48 27,59.56 26.92,59.59 26.72,59.59 26.67,59.58 26.58,59.58 26.49,59.67 26.49,60.91 26.53,60.95 26.71,60.95
PP5000_U on TOP (solid shape): 181.66,58.57 181.76,58.54 182.79,57.51 182.79,57.38 182.55,57.14 182.2,57.14 182.05,57.29 182.05,57.36 181.98,57.65 181.7,57.77 181.31,57.77 181.08,57.55 180.91,57.71 180.91,57.82 180.91,57.9 180.99,57.99 181.04,57.99 181.28,58.23 181.3,58.23 181.48,58.33 181.59,58.5
PP5000_U on TOP (solid shape): 162.37,71.72 162.53,71.72 162.56,71.7 162.78,71.7 162.81,71.7 162.9,71.72 163.91,71.72 164.01,71.7 164.17,71.7 164.22,71.64 164.22,71.46 164.46,71.22 164.46,71.21 164.5,71.12 164.55,71.03 164.55,69.89 164.41,69.74 164.3,69.85 164.23,69.91 164.13,69.94 164.09,69.95 164.09,70.46 164.07,70.48 164.07,70.55 163.96,70.81 163.69,70.93 163.67,70.93 163.64,70.94 161.42,70.94 161.31,71.05 161.29,71.05 161.11,71.23 161.11,71.65 161.6,72.14 161.96,72.14
PP5000_U on TOP (solid shape): 21.79,59.2 22.71,59.2 22.79,59.12 22.79,58.85 22.76,58.82 22.76,58.66 22.76,58.03 22.65,57.93 22.65,57.88 22.62,57.81 22.55,57.78 22.54,57.78 22.19,57.43 22.54,57.07 22.77,57.15 22.89,57.35 22.89,57.37 23.97,57.37 24.02,57.32 24.02,56.56 23.51,56.44 23.02,56.26 23.01,56.25 20.77,56.25 20.51,56.51 20.51,58.13 20.52,58.14 20.52,58.51 20.51,58.52 20.51,58.65 21.06,59.2 21.79,59.2
PP5000_U on IN2 (solid shape): outline of 1388 points within 20.21,20.08 33.98,60.13
PP5000_U_R on TOP (solid shape): 33.7,36.43 33.7,30.18 32.77,29.26 32.76,29.26 31.9,28.4 30.08,28.4 29.89,28.58 29.89,37.61 30.07,37.79 32.34,37.79
PP5000_USB_A0_VBUS on TOP (solid shape): 17.62,62.89 22.62,62.89 22.76,62.75 22.76,61.7 22.76,61.39 22.73,61.36 22.27,61.36 22.23,61.32 14.4,61.32 13.99,61.73 13.99,63.58 14.13,63.73 16.78,63.73
PP5000_USB_A0_VBUS on IN2 (solid shape): outline of 198 points within 10.36,59.07 18.46,62.81
PPVAR_BAT on BOTTOM (solid shape): 92.86,18.5 92.86,16.19 92.6,15.93 88.73,15.93 88.62,15.82 88.52,15.87 88.42,15.88 88.17,15.78 88.06,15.53 88.08,15.42 88.12,15.33 87.96,15.16 86.19,15.16 86.14,15.17 86.09,15.18 86.03,15.17 85.98,15.16 85.86,15.16 85.74,15.27 85.74,16.19 86,16.44 86,18.52 86.09,18.6 92.75,18.6
PPVAR_BL_PWR on TOP (solid shape): 45.17,66.42 45.17,63.75 44.98,63.56 41.72,63.56 41.72,66.53 42.06,66.86 44.72,66.86
PPVAR_BL_PWR on BOTTOM (solid shape): outline of 381 points within 42.12,60.95 57.9,70.11
PPVAR_KB_BL on TOP (solid shape): 72.45,13.51 72.45,12.58 71.33,11.45 71.33,9.73 71.17,9.57 69.63,9.57 69.51,9.69 69.51,12.03 70.11,12.63 70.11,13.49 70.33,13.71 72.25,13.71
PPVAR_KB_BL on BOTTOM (solid shape): 75.42,18.45 75.42,16.71 75.24,16.53 75.24,11.47 74.76,10.98 71.52,10.98 71.04,11.47 71.04,13.27 71.19,13.42 72,13.42 72.02,13.42 72.05,13.43 72.15,13.43 72.92,14.2 72.92,18.16 73.31,18.55 75.32,18.55
PPVAR_KB_BL_D on TOP (solid shape): 77.42,10.94 77.42,10.85 77.42,8.39 76.79,7.76 76.78,7.76 76.69,7.67 69.75,7.67 69.57,7.85 69.57,9.11 69.84,9.37 71.44,9.37 71.77,9.7 75.19,9.7 76.47,10.99 77.38,10.99
PPVAR_SYS on TOP (solid shape): outline of 4953 points within 41.29,10.72 192.68,87.18
PPVAR_SYS on BOTTOM (solid shape): 82.7,21.02 82.7,19.11 82.53,18.94 80.1,18.94 79.8,19.24 79.77,19.24 79.65,19.37 79.65,20.76 80.03,21.14 82.57,21.14
PPVAR_SYS on BOTTOM (solid shape): 58.01,30.74 58.08,30.74 58.29,30.54 64.06,30.54 64.54,30.05 64.54,25.73 64.28,25.46 56.53,25.46 55.98,26.01 53.99,28.01 49.85,28.01 49.45,28.4 49.45,29.77 58.87,29.77 58.87,29.72 58.88,29.66 58.89,29.61 58.92,29.56 58.95,29.52 58.98,29.48 59.02,29.45 59.07,29.42 59.12,29.4 59.17,29.39 59.23,29.39 59.28,29.39 59.33,29.4 59.38,29.42 59.43,29.45 59.47,29.48 59.5,29.52 59.53,29.56 59.56,29.61 59.57,29.66 59.58,29.72 59.58,29.77 59.57,29.82 59.56,29.87 59.53,29.92 59.5,29.96 59.47,30 59.43,30.04 59.38,30.06 59.33,30.08 59.28,30.09 59.23,30.1 59.17,30.09 59.12,30.08 59.07,30.06 59.02,30.04 58.98,30 58.95,29.96 58.92,29.92 58.89,29.87 58.88,29.82 58.87,29.77 49.45,29.77 49.45,31.44 50.18,32.17 56.58,32.17
PPVAR_SYS on BOTTOM (solid shape): 195.47,27.11 195.47,21.93 194.43,20.89 189.45,20.89 189.01,21.32 189.01,22.3 193.72,22.3 193.72,22.5 192.94,22.5 192.94,22.3 189.01,22.3 189.01,22.8 193.72,22.8 193.72,23 192.94,23 192.94,22.8 189.01,22.8 189.01,23.3 193.72,23.3 193.72,23.5 192.94,23.5 192.94,23.3 189.01,23.3 189.01,23.8 193.72,23.8 193.72,24 192.94,24 192.94,23.8 189.01,23.8 189.01,24.3 193.72,24.3 193.72,24.5 192.94,24.5 192.94,24.3 189.01,24.3 189.01,24.8 193.72,24.8 193.72,25 192.94,25 192.94,24.8 189.01,24.8 189.01,25.3 193.72,25.3 193.72,25.5 192.94,25.5 192.94,25.3 189.01,25.3 189.01,25.8 193.72,25.8 193.72,26 192.94,26 192.94,25.8 189.01,25.8 189.01,26.3 193.72,26.3 193.72,26.5 192.94,26.5 192.94,26.3 189.01,26.3 189.01,26.8 193.72,26.8 193.72,27 192.94,27 192.94,26.8 189.01,26.8 189.01,26.81 189.51,27.3 193.72,27.3 193.72,27.5 192.94,27.5 192.94,27.3 189.51,27.3 189.83,27.62 192.68,27.62 192.86,27.8 193.74,27.8 193.87,27.8 193.87,27.81 194.78,27.81
PPVAR_SYS on IN1 (solid shape): outline of 2988 points within 96.75,11.73 196.06,78.06
PPVAR_SYS_1V1_DRAM on TOP (solid shape): 176.95,40.9 176.95,35.21 177.77,34.39 177.77,32.83 177.35,32.41 173.3,32.41 173.17,32.55 173.17,37.81 172.77,38.21 172.77,40.55 172.7,40.62 171.85,40.62 171.68,40.79 171.68,41.04 171.81,41.16 176.69,41.16
PPVAR_SYS_VCCIN_AUX on TOP (solid shape): 49.81,62.24 49.81,59.84 48.6,59.84 48.28,60.16 48.28,61.38 47.97,61.68 47.97,62.7 49.34,62.7
PPVAR_USB_C0_VBUS on TOP (solid shape): 50.49,12.98 50.49,10.42 49.93,9.87 46.89,9.87 46.59,10.17 46.59,12.89 46.85,13.14 50.32,13.14
PPVAR_USB_C0_VBUS on TOP (solid shape): 72.45,15.95 72.45,14.08 72.36,14 70.94,14 70.85,14.09 70.85,14.5 70.85,16.22 70.97,16.34 72.06,16.34
PPVAR_USB_C0_VBUS on TOP (solid shape): 8.59,75.55 8.74,75.55 8.96,75.33 8.96,74.78 8.87,74.69 8.02,74.69 7.73,74.97 5.44,74.97 5.24,74.78 4.64,74.78 4.42,74.99 4.42,75.21 4.64,75.42 5.2,75.42 5.32,75.42 5.52,75.23 5.8,75.23 5.8,75.22 6.56,75.22 6.73,75.39 7,75.39 7.34,75.73 8.41,75.73
PPVAR_USB_C0_VBUS on TOP (solid shape): 5.52,72.73 5.8,72.73 5.8,72.72 8.08,72.72 8.15,72.7 8.22,72.69 8.29,72.7 8.36,72.72 8.42,72.72 8.65,72.96 8.96,72.96 9.09,72.83 9.09,72.53 8.89,72.33 8.81,72.27 8.75,72.19 8.53,71.97 7.46,71.97 7.16,72.27 6.73,72.27 6.52,72.48 5.8,72.48 5.8,72.47 5.48,72.47 5.37,72.36 4.66,72.36 4.48,72.54 4.48,72.76 4.68,72.96 5.28,72.96
PPVAR_USB_C0_VBUS on BOTTOM (solid shape): 49.19,12.2 49.19,10.02 48.89,9.72 46.78,9.72 46.62,9.88 46.62,12.16 46.76,12.3 49.09,12.3
PPVAR_USB_C0_VBUS on IN3 (solid shape): outline of 6773 points within 4.42,9.59 72.37,75.75
PPVAR_USB_C0_VIN on TOP (solid shape): 53.11,12.11 53.11,10.8 52.4,10.09 52.4,9.54 52.4,9.54 52.4,8.85 52.2,8.65 51.53,8.65 51.39,8.52 51.39,8.32 50.98,7.91 49.61,7.91 49.51,8.01 49.51,9.26 50.94,10.69 50.94,12.06 51.1,12.22 53,12.22
