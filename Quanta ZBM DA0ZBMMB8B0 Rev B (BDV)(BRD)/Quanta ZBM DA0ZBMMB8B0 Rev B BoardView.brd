# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PP5000_USB_A0_VBUS:
  vias: v4(17.51,62.38) v4(17.51,61.73) v4(18.15,62.38) v4(18.15,61.73) v4(20.83,62.46)
PP5000_USB_C0_VCONN: length 3.7
  TOP w0.203: v2(62.76,21.19) 62.76,21.17 62.61,21.02 U9.33
  BOTTOM w0.508: v2(62.76,21.19) 62.57,21.38 C1012.1 62.57,23.99 R1026.1
PPVAR_BAT: length 33.6
  TOP w0.203: U9.7 58.17,17.47 v2(57.94,17.24)
  IN2 w0.508: v2(57.94,17.24) 58.26,17.56 63.42,17.56 65.38,15.6 69.52,15.6 69.94,15.17 77.89,15.17 78.22,14.84 84.51,14.84 85.14,14.22 86.95,14.22 87.71,14.98 v2(87.71,15.56)
PPVAR_BL_PWR:
  vias: v4(42.44,65.85) v4(42.56,66.48) v4(43.07,65.85) v4(43.2,66.48)
PPVAR_KB_BL:
  vias: v3(71.42,13.08) v3(71.75,12.41) v3(72.15,13.08)
PPVAR_KB_BL_D:
  vias: v4(76.78,8.85)
PPVAR_SYS: length 19.6
  TOP w0.203: U9.21 64.96,16.27 65.89,15.34 67.24,15.34 67.52,15.62 67.52,16.7 68.41,17.59 68.41,18.04
  TOP w0.254: 180.61,63.05 175.94,63.05 175.02,62.14 175.02,61.02 175.91,60.13 176.8,60.13 177.08,59.86 R129.2
  BOTTOM w0.254: R228.2 82.92,18.84 82.92,19.77 82.74,19.95 U19.2
  vias: v3(97.6,12.63) v3(98.34,12.63) v3(99.12,12.63) v3(99.85,12.65) v3(100.6,12.66) v3(101.34,12.66) v3(102.11,12.66) v3(102.85,12.66) v3(182.29,77.56) v3(183.04,77.36) v3(183.04,76.56) v3(183.73,77.66) v3(183.73,76.86) v3(183.73,76.07) v3(184.43,77.26) v3(184.43,76.47) v3(184.43,75.68) v3(189.76,26.1) v3(189.76,25.33) v3(189.76,24.57) v3(190.52,26.1) v3(190.52,25.33) v3(190.52,24.57) v3(190.52,23.81) v3(191.28,26.1) v3(191.28,25.33) v3(191.28,24.57) v3(191.28,23.81) v3(192.04,26.1) v3(192.04,25.33) v3(192.04,24.57) v3(192.04,23.81) v4(49.23,38.23) v4(50.28,30.68) v4(50.44,31.3) v4(50.78,30.21) v4(50.89,30.85) v4(52.94,28.89) v4(61.8,26.69) v4(61.8,26.06) v4(62.43,26.69) v4(62.43,26.06) v4(63.07,26.69) v4(63.07,26.06) v4(80,20.58) v4(80.03,19.93) v4(80.66,20.56) v4(80.66,19.93) v4(80.66,19.29) v4(81.3,20.56) v4(81.3,19.93) v4(81.3,19.29)
PPVAR_SYS_1V1_DRAM: length 11.2
  TOP w0.254: R441.2 185.52,41.26 v2(185.18,41.59)
  IN2 w0.254: v2(185.18,41.59) 182.52,38.92 180.36,38.92 178.8,37.36 v2(176.55,37.36)
  vias: v4(175.56,35.42)
PPVAR_SYS_IMVP9_VIN: length 3.7
  TOP w0.203: U10.22 179.07,56.41 178.79,56.68 v4(178.77,56.68) 178.77,57.31 178.4,57.68 C230.1 177.25,57.68 R129.1
PPVAR_SYS_VCCIN_AUX:
  vias: v4(49.34,61.99)
PPVAR_USB_C0_VBUS:
  vias: v2(7.28,75.28) v2(7.64,72.5) v2(7.88,75.28) v2(8.2,72.31) v3(46.93,11.98) v3(46.93,11.21) v3(46.93,10.42) v3(47.68,11.98) v3(47.68,11.21) v3(47.68,10.42) v3(71.16,16.03) v3(71.9,16.03) v4(47.08,12.69)
PPVAR_USB_C0_VIN: length 11.9
  TOP w0.254: U18.1 53.08,11.51 53.33,11.25 53.33,10.39 R224.1
  BOTTOM w0.254: v2(51.84,11.66) 53.94,11.66 54.34,12.07 54.34,12.82 56.15,14.63 R27309.1
  vias: v4(51.76,9.76)
PPVAR_USB_C0_VIN_R: length 2.1
  TOP w0.254: U18.2 53.94,11.51 53.73,11.29 53.73,10.26 R226.2
  vias: v4(55.8,16.98)
PPVAR_VBAT_U: length 2.3
  BOTTOM w0.254: R229.1 83.3,18.75 83.3,19.85 83.41,19.95 U19.1
  vias: v4(84.4,21.19)
PPVAR_VCC_IN_SNS_N: length 67.1
  TOP w0.109: v2(182.84,54.02) 182.69,53.87 182.12,53.87 182.07,53.82 U10.13 ; v2(142.13,67.86) 142.74,68.46 R27121.1 ; U1JSL.J24 v1(130.43,63.39)
  IN1 w0.097: v2(182.84,54.02) 182.99,54.16 183.25,54.16 183.53,54.45 183.53,55.53 183.05,56.01 181.95,56.01 179.9,58.07 178.36,58.07 177.44,58.99 177.44,59.91 176.4,60.94 174.5,60.94 173.32,62.12 173.32,64.63 171.26,66.69 159.48,66.69 159.01,67.16 150.23,67.16 149.73,67.66 142.33,67.66 v2(142.13,67.86) 141.95,68.04 139.6,68.04 139.17,67.61 136.28,67.61 134.61,65.95 134.18,65.95 133.51,65.28 131.89,65.28 130.5,63.9 130.5,63.46 v1(130.43,63.39)
PPVAR_VCC_IN_SNS_P: length 71.5
  TOP w0.109: v2(141.57,67.65) 141.8,67.42 142.33,67.42 142.38,67.47 R27120.2 ; v2(182.84,54.69) 182.84,54.56 182.36,54.08 182.18,54.08 182.04,54.22 U10.14 ; U1JSL.H24 130.69,63.01 130.69,63.16 130.92,63.39 v1(131.09,63.39)
  IN1 w0.097: v1(131.09,63.39) 130.93,63.39 130.7,63.61 130.7,63.82 131.97,65.09 133.6,65.09 134.26,65.75 134.69,65.75 136.36,67.42 139.25,67.42 139.68,67.84 141.38,67.84 v2(141.57,67.65) 141.76,67.46 149.65,67.46 150.15,66.96 158.93,66.96 159.4,66.49 171.18,66.49 173.12,64.55 173.12,62.04 174.41,60.74 176.32,60.74 177.24,59.82 177.24,58.91 178.28,57.87 179.81,57.87 181.87,55.81 182.96,55.81 183.33,55.44 183.33,54.53 183.17,54.36 183,54.36 182.84,54.53 v2(182.84,54.69)
  BOTTOM w0.109: v2(182.84,54.69) 183.18,55.03 183.18,55.62 182.78,56.02 R428.2 182.78,57.93 182.72,57.98 C405.1
PPVAR_VCCIN: length 12
  TOP w0.203: L27202.2 160.91,60.62 161.44,61.15 161.44,64.45 160.26,65.62 160.26,66.13 R27223.1
  vias: v1(127.15,67.14) v1(127.78,67.14) v1(127.79,63.39) v1(128.45,63.39) v1(129.05,67.17) v1(129.11,63.39) v1(129.71,69.07) v1(129.77,63.39) v1(130.32,67.17) v1(130.45,69.07) v1(131.08,69.07) v2(125.72,64.51) v2(127.81,65.47) v2(128.45,64.47) v2(128.47,65.47) v2(129.13,65.47) v2(129.15,68.13) v2(129.79,68.13) v2(129.79,65.47) v2(129.77,64.47) v2(130.42,68.13) v2(130.45,65.47) v2(131.06,68.13) v2(131.11,65.47) v3(152.57,64.58) v3(152.93,63.89) v3(153.03,60.26) v3(153,59.5) v3(153,58.74) v3(153.31,64.58) v3(153.71,63.88) v3(153.71,63.15) v3(154.07,64.58) v3(154.17,58.04) v3(154.5,63.88) v3(154.5,63.15) v3(154.83,64.6) v3(154.95,58.04) v3(155.28,63.88) v3(155.28,63.15) v3(155.59,64.6) v3(155.74,58.04) v3(156.07,63.88) v3(156.07,63.15) v3(156.48,64.58) v3(156.53,58.04) v3(156.86,63.88) v3(156.86,63.15) v3(157.27,64.65) v3(157.32,58.04) v3(157.63,63.97) v3(157.63,63.13) v3(158.01,64.65) v3(158.09,62.45) v3(158.26,59.96) v3(158.26,59.22) v3(158.26,58.48) v3(158.39,63.97) v3(158.39,63.18) v3(158.85,62.45) v3(159.02,59.96) v3(159.02,59.2) v3(159.02,58.46) v3(159.15,63.94) v3(159.15,63.18) v3(159.61,62.47) v3(159.78,59.96) v3(159.78,59.2) v3(159.78,58.46) v3(159.91,63.94) v3(159.91,63.18) v3(160.42,62.42) v3(160.55,59.98) v3(160.55,59.22) v3(160.55,58.46) v3(160.65,63.16) v3(160.67,63.89) v4(142.11,64.32) v4(142.08,63.69) v4(142.54,63.05) v4(142.72,63.69) v4(142.77,64.32) v4(143.17,63.05) v4(143.4,64.32) v4(143.35,63.69) v4(149.5,72.58) v4(157.12,53.85)
PPVAR_VCCIN_AUX: length 37.6
  TOP w0.254: v2(111.96,65.31) U1JSL.BJ20 112.43,64.94 v2(112.82,65.3) ; v2(111.96,65.31) 112.33,65.67 U1JSL.BJ18 ; v2(111.96,65.31) 111.62,65 U1JSL.BK20 ; v2(111.96,65.31) 111.62,65.66 U1JSL.BK18 111.62,65.72 v2(111.96,66.03) ; v2(112.82,66.03) U1JSL.BJ18 ; v2(112.82,66.03) 112.43,66.39 U1JSL.BJ17 112.33,66.39 v2(111.96,66.03) ; v2(112.82,66.03) 113.15,65.71 U1JSL.BG18 ; v2(112.82,66.03) 113.15,66.34 U1JSL.BG17 v2(113.51,66.01) ; U1JSL.BJ18 112.38,65.66 v2(111.96,66.03) ; U1JSL.BJ18 v2(112.82,65.3) ; v2(113.51,66.01) 113.48,66.01 113.15,65.69 U1JSL.BG18 ; v2(113.51,66.01) U1JSL.BE17 v2(114.29,66.03) ; v2(113.51,66.01) U1JSL.BE18 ; U1JSL.BK17 111.62,66.38 v2(111.96,66.03) ; U1JSL.BE18 v2(114.29,66.03) ; U1JSL.BE18 v2(114.29,65.3) ; U1JSL.BE18 v2(113.51,65.28) ; v2(114.29,66.03) U1JSL.BD18 ; v2(114.29,66.03) U1JSL.BD17 v2(115.03,66.01) U1JSL.BD18 ; U1JSL.BD18 v2(115.03,65.28) U1JSL.BD20 v2(114.29,65.3) ; U1JSL.BD18 v2(114.29,65.3) ; v2(114.29,65.3) U1JSL.BE20 ; U1JSL.BG18 113.15,65.62 v2(112.82,65.3) ; U1JSL.BG18 113.15,65.64 113.48,65.28 v2(113.51,65.28) ; v2(112.82,65.3) 113.15,64.99 U1JSL.BG20 v2(113.51,65.28)
  IN4 w0.381: v2(68.28,54.48) 66.82,53.02 55.14,53.02 54.02,54.13 v2(53.05,54.13)
  BOTTOM w0.381: v2(53.05,54.13) 53.05,54.16 52.68,54.54 R241.1
  vias: v4(74.54,64.82) v4(74.59,62.21) v4(74.64,61.57) v4(74.95,62.83) v4(75.23,62.23) v4(75.28,61.6) v4(75.61,63.02) v4(75.86,62.29) v4(76.24,63.02) v4(89.4,79.11) v4(89.81,78.57) v4(90.16,79.11) v4(90.54,78.57) v4(90.9,79.11) v4(91.25,78.57) v4(91.64,79.1) v4(92.02,78.57) v4(92.4,79.1) v4(92.78,78.57) v4(93.13,79.12) v4(93.57,78.57) v4(93.92,79.12) v4(94,80.43) v4(94.3,78.57) v4(94.68,79.1) v4(95.17,78.57) v4(95.73,79.54) v4(96.61,78.56) v4(97.24,79.21) v4(97.26,78.56) v4(97.9,78.56) v4(98.54,78.56) v4(99.19,78.56) v4(99.45,79.16) v4(99.83,78.56) v4(105.12,80.2)
PPVAR_VNNEXT: length 12.5
  TOP w0.254: U1JSL.CA20 v2(107.41,64.56) U1JSL.BW20 v2(108.19,64.58) U1JSL.BU20 v2(108.94,64.56) U1JSL.BT20 v2(109.72,64.58) 109.87,64.73 U1JSL.BP20 ; U33.16 60.02,34.41 60.57,33.86 60.57,31.95 60.91,31.61 63.74,31.61 L10.2
  vias: v4(66.19,33.82) v4(70.74,33.87) v4(70.74,33.24) v4(70.74,32.6) v4(70.74,31.97) v4(75.84,58.42) v4(75.84,57.78) v4(76.48,58.42) v4(76.48,57.77)
PROCHOT_ODL: length 266
  TOP w0.109: v1(156.99,16.3) 156.99,16.83 156.71,17.11 R145.2 ; R27113.1 177.38,48.92 178.38,47.93 178.38,46.9 179.55,45.73 182.13,45.73 182.73,46.33 184.11,46.33 v2(184.9,47.12) 184.9,47.22 185.72,48.04 186.59,48.04 186.83,47.79 186.83,46.66 188.67,44.82 188.67,40.49 187.97,39.79 v2(187.95,39.79) ; v2(123.59,84.77) 123.17,84.35 R8603.2 R8609.2 123.17,82.72 122.93,82.48 R8606.2
  IN2 w0.097: v2(187.95,39.79) 187.63,39.79 185.34,37.5 185.34,33.2 184.06,31.92 170.87,31.92 170.45,31.51 170.45,29.91 167.66,27.11 167.66,26.48 167.02,25.84 167.02,25.39 166.71,25.07 166.25,25.07 165.63,24.45 165.63,23.05 164.32,21.74 164.32,19.27 163.16,18.12 159.46,18.12 157.64,16.3 v1(156.99,16.3) 156.6,15.91 154.88,15.91 154.03,16.76 151.59,16.76 147.63,12.8 113.89,12.8 109.89,16.8 108.06,16.8 107.23,15.96 104.6,15.96 103.28,14.64 94.01,14.64 92.2,16.44 78.41,16.44 77.65,17.21 66.13,17.21 65.86,17.48 v2(65.32,17.48) ; v2(184.9,47.12) 184.9,47.72 185.99,48.81 185.99,50.37 187.08,51.46 187.08,59.62 186.36,60.34 186.36,70.19 176.55,80.01 169.35,80.01 167.2,82.17 149.71,82.17 v2(148.85,83.03)
  IN4 w0.089: v2(123.59,84.77) 123.59,84.72 124.05,84.26 124.41,84.26 124.61,84.46 124.61,84.77 125.17,85.34 136.05,85.34 138.94,82.44 144.1,82.44 144.69,83.03 v2(148.85,83.03)
  BOTTOM w0.114: v2(65.32,17.48) 65.01,17.78 R363.2
PSYS: length 172
  TOP w0.109: U10.9 181.97,52.22 182.2,51.99 182.2,51.69 182.39,51.5 182.39,49.63 182.46,49.56 C27101.2 R311.1 183.41,49.4 184.14,48.66 184.96,48.66 185.3,49.01 186.69,49.01 187.08,48.61 187.08,47 v2(187.58,46.5) ; R225.1 59.33,12.44 v2(59.34,12.43)
  IN2 w0.079: 158.44,25.07 157.98,24.61 157.98,23.58 v1(158.31,23.25)
  IN2 w0.097: v2(187.58,46.5) 187.58,46.33 186.69,45.44 186.69,43.26 186.21,42.79 186.21,40.05 184.42,38.26 184.42,36.41 180.15,32.14 170.78,32.14 170.24,31.6 170.24,29.97 169.35,29.08 166.93,29.08 164.57,26.72 163.61,26.72 162.71,25.82 162.71,25.44 162.35,25.08 160.69,25.08 159.87,25.89 159.26,25.89 158.44,25.07 ; v2(59.34,12.43) 60.56,12.43 62.02,13.89 77.11,13.89 77.42,13.57 79.05,13.57 79.85,12.77 79.85,11.99 80.16,11.68 107.71,11.68 108.44,12.41 108.93,12.41 v2(109.31,12.03) ; v1(158.31,23.25) 158.31,23.23 157.96,22.87 157.5,22.87 157.22,22.59 157.22,21.91 156.4,21.09 153.76,21.09 153.05,20.38 152.45,20.38 152.16,20.67 148.16,20.67 143.01,15.53 117.17,15.53 v2(114.6,18.1)
  BOTTOM w0.114: v2(109.31,12.03) 109.43,12.14 109.43,14.71 109.61,14.88 111.38,14.88 v2(114.6,18.1)
  BOTTOM w0.254: v1(158.31,23.25) 158.31,23.39 157.98,23.72 157.51,23.72 157.16,24.07 C155.2 156.63,24.42 156.63,25.01 156.4,25.24 R202.1
PWR_BTN_ODL: length 314.1
  TOP w0.109: Q22.3 160.42,16.82 v1(160.42,16.34) ; v2(80.25,12.16) 80,12.4 80,15.78 80.35,16.13 85.81,16.13 86.5,15.44 Q16.2 ; v2(168.15,26.78) 168.21,26.84 U1.18 ; SW1.3 6.14,4.17 6.6,4.63 6.6,6.02 v2(6.1,6.51) 5.99,6.63 SW1.1 ; R284.1 R193.2 R99.2 124.3,21.44 v2(123.83,20.97)
  IN2 w0.097: v1(160.42,16.34) 160.98,16.9 160.98,17.22 161.57,17.82 165.23,17.82 165.63,18.21 165.63,22.77 166.52,23.66 166.52,24.5 167.43,25.41 167.43,25.97 167.88,26.42 167.88,26.52 v2(168.15,26.78) ; v2(91.34,12.29) 90.95,11.9 80.51,11.9 v2(80.25,12.16) 80.25,12.73 79.19,13.79 77.54,13.79 77.23,14.1 64.98,14.1 63.72,15.35 59.74,15.35 54.37,9.98 52.61,9.98 50.62,8 28.64,8 25.93,10.71 22.36,10.71 15.81,17.27 10.69,17.27 8.6,15.19 8.6,9.01 v2(6.1,6.51)
  IN4 w0.089: v1(160.42,16.34) 160.42,17.41 159.61,18.22 156.55,18.22 156.23,18.54 156.23,20.25 155.76,20.71 153.82,20.71 153.43,21.1 153.43,21.78 153.31,21.91 152.8,21.91 152.1,21.21 152.1,19.83 151.33,19.05 149.02,19.05 145.59,15.61 143.69,15.61 143.54,15.47 115.12,15.47 v2(114.97,15.62) 114.57,16.02 111.11,16.02 109.87,17.26 103,17.26 101.96,16.22 97.43,16.22 v2(97.04,16.61) 96.64,17.01 94.83,17.01 90.66,21.18 85.04,21.18 81.65,24.57 77.49,24.57 75.32,26.73 75.32,34.16 77.59,36.42 77.59,46.26 76.56,47.3 76.56,51.65 75.46,52.75 75.46,56.12 76.1,56.77 76.78,56.77 78.58,58.57 78.58,61.36 87.24,70.03 91.05,70.03 91.57,69.51 91.63,69.51 v2(91.97,69.18)
  BOTTOM w0.114: v2(123.83,20.97) 123.24,20.38 116.95,20.38 115.26,18.69 115.26,15.92 v2(114.97,15.62) ; v2(91.97,69.18) 91.56,68.77 R44.1 ; v2(97.04,16.61) 96.39,15.96 95.01,15.96 v2(91.34,12.29)
RAM_STRAP_0: length 10.1
  TOP w0.089: 98.44,68.52 98.9,68.52 99.35,68.07 100.8,68.07 100.84,68.03 101.41,68.03 U1JSL.CN13
  TOP w0.109: 98.44,68.52 97.68,68.52 97.17,69.02 96.03,69.02 95.77,69.28 95.45,69.28 95.19,69.53 94.29,69.53 94.15,69.39 93.49,69.39 93.34,69.54 R420.1 93.34,70.25 93.54,70.45 R419.2
RAM_STRAP_1: length 6.9
  TOP w0.089: U1JSL.CR14 100.69,67.6 99.18,67.6 98.81,67.98 98.44,67.98
  TOP w0.109: 98.44,67.98 97.33,67.98 97.1,68.21 96.17,68.21 96.12,68.26 v4(95.73,68.26) 95.65,68.34 R418.1 95.06,68.39 94.61,68.84 R417.2
RAM_STRAP_2: length 10.8
  TOP w0.089: U1JSL.CN11 101.27,68.98 100.9,69.35 100.58,69.35 100.1,69.58 98.97,69.58 98.79,69.76
  TOP w0.109: 98.79,69.76 98.07,70.48 98.07,70.54 97.38,71.23 96.37,71.23 96.23,71.1 96.23,70.78 96.12,70.67 95.35,70.67 95.24,70.78 95.24,71.14 R416.1
  TOP w0.117: R415.2 93.03,71.25 93.74,71.25 93.91,71.08 94.28,71.08 94.34,71.02 94.86,71.02 94.98,71.14 R416.1
RAM_STRAP_3: length 16.5
  TOP w0.089: v1(104.13,68.61) 104.1,68.61 103.91,68.41 U1JSL.CH13
  TOP w0.109: v2(91.31,70.9) 91.68,70.9 R413.2 R414.1
  BOTTOM w0.089: 101.13,68.74 101.45,68.42 102.87,68.42 103.43,68.99 103.75,68.99 v1(104.13,68.61)
  BOTTOM w0.114: 95.04,70.14 v4(94.38,70.8) 93.92,70.8 93.74,70.98 91.41,70.98 91.33,70.9 v2(91.31,70.9)
  BOTTOM w0.117: 95.04,70.14 95.17,70.01 95.17,69.78 95.42,69.53 96.61,69.53 96.71,69.44 97.41,69.44 97.73,69.76 100.06,69.76 100.51,69.31 100.56,69.31 101.13,68.74
RAM_STRAP_4: length 17.4
  TOP w0.109: v2(105.99,61.61) 105.99,61.88 U1JSL.CC26 ; R314.2 R341.1 95.11,55.1 v2(94.96,55.26)
  IN4 w0.089: v2(94.96,55.26) 94.96,55.51 95.17,55.72 95.83,55.72 97.76,57.65 101.04,57.65 102.71,59.32 106.19,59.32 106.52,59.65 106.52,61.07 v2(105.99,61.61)
RSMRST_PWRGD_L: length 139.7
  TOP w0.079: U17.B11 150.64,27.21 150.34,27.51 150.34,27.8 150.01,28.13 149.73,28.13
  TOP w0.109: v1(149.4,28.13) 149.73,28.13
  TOP w0.117: v2(90.9,46) 90.9,46.34 D34.1
  IN1 w0.097: v2(130.52,23.45) 131.4,24.34 138.44,24.34 140.47,26.37 142.93,26.37 145.07,28.51 149.01,28.51 v1(149.4,28.13)
  IN2 w0.097: v2(90.9,46) 90.87,45.98 90.87,45.72 88.74,43.58 88.74,30.08 91.33,27.49 91.33,26.73 92.03,26.04 99.41,26.04 100.24,25.21 113.95,25.21 114.8,24.36 129.61,24.36 v2(130.52,23.45)
  BOTTOM w0.114: v4(86.18,45.46) 83.09,42.36 79.53,42.36 77.08,39.92 71.12,39.92 70.36,39.17 62.08,39.17 60.93,40.32 51.99,40.32 51.67,39.99 51.67,37.62 52.53,36.76 D36.2 53.36,37.72 54.12,38.48 56.52,38.48 56.72,38.68 56.72,39.3 57.09,39.67 R13.1
  BOTTOM w0.117: v4(86.18,45.46) 90.53,45.46 90.87,45.8 90.87,45.98 v2(90.9,46)
RSPK_LDO: length 2.1
  TOP w0.109: U4.19 27.76,12.58 28.6,11.74 C142.1
RSPK_N: length 8.3
  TOP w1.016: 29.36,16.84 29.36,25.11
  vias: v2(29.09,26.43) v2(29.09,25.84)
RSPK_P: length 7.1
  TOP w1.016: 25.19,20.01 25.19,21.34 25.91,22.06 27.1,22.06 27.99,22.96 27.99,25.21
  vias: v2(28.02,26.43) v2(28.02,25.84)
RSPK_VCM: length 2
  TOP w0.109: U4.20 27.61,13.08 28.27,12.43 C141.1
RSVD_STRAP: length 3.7
  TOP w0.109: v2(106.62,62.52) 105.59,62.52 U1JSL.CE26
  BOTTOM w0.114: R105.2 107.12,63.78 107.07,63.84 R107.1 106.69,62.6 v2(106.62,62.52)
RTC_RST_L: length 32.3
  TOP w0.089: U1JSL.BP47 110.04,52.54 109.86,52.36 109.86,52.12 110.08,51.9 110.13,51.81 110.14,51.78 110.14,51.78 110.15,51.77 110.15,51.42 110.26,51.23 110.26,50.99 110.18,50.91 110.18,49.34 109.42,48.58 109.42,48.05 106.01,44.63 106.01,44.14 v4(105.98,44.11)
  TOP w0.109: 86.89,40.54 Q20.3
  TOP w0.117: v4(105.98,44.11) 104.51,42.65 93.66,42.65 93.11,42.1 90.47,42.1 89.65,41.28 88.22,41.28 R3C23.2 88.2,41.02 87.97,40.79 C3C8.1 87.46,40.42 87.34,40.54 86.89,40.54
SD3_RCOMP: length 7.7
  TOP w0.089: 100.42,50.03 101.25,50.03 101.65,50.43 101.65,50.84 U1JSL.CM50
  TOP w0.18: RT756.1 95.73,51.41 96.54,50.61 97.59,50.61 98.17,50.03 100.42,50.03
SD_CD_ODL: length 112.1
  TOP w0.089: v2(104.54,48.58) 104.67,48.58 105.27,49.18 105.27,50.14 105.19,50.22 105.19,50.79 105.12,50.96 U1JSL.CE50
  TOP w0.109: J9.9 13.98,31.15 14.36,30.77 CR7.1 R424.2 v2(15.51,31.23)
  BOTTOM w0.114: v2(15.51,31.23) 15.51,30.88 16.5,29.89 20.38,29.89 23.5,33 23.5,33.54 26.31,36.35 26.31,37.91 28.34,39.94 38.37,39.94 39.36,38.95 45.47,38.95 50.44,43.92 61.59,43.92 62.97,42.54 69.04,42.54 70.12,43.62 72.3,43.62 73.26,44.59 74.62,44.59 75.51,45.48 80.59,45.48 84.29,49.19 90.29,49.19 90.7,49.59 v4(90.7,52.39) 91.08,52.77 96.54,52.77 98.85,50.46 100.37,50.46 101.28,49.55 103.77,49.55 104.54,48.78 v2(104.54,48.58)
SD_CLK: length 110.5
  TOP w0.089: v2(104.07,48.09) 104.07,48.77 104.42,49.12 104.9,49.12 105.09,49.31 105.09,50.03 105.01,50.11 105.01,50.76 104.76,51.01 U1JSL.CF49
  TOP w0.109: v2(15.39,27.68) 15.2,27.68 14.87,27.35 CR2.1 14.36,27.35 14.32,27.31 14.02,27.31 13.56,26.85 J9.5
  BOTTOM w0.109: v2(104.07,48.09) 103.9,48.26 103.9,48.72 103.57,49.05 101.08,49.05 100.18,49.95 94.05,49.95 93.18,49.07 91.64,49.07 91.16,48.59 85.82,48.59 85.12,47.9 84.97,47.9 84.41,48.45 84.26,48.45 84.07,48.26 84.07,48.11 84.62,47.55 84.62,47.4 84.43,47.2 84.28,47.2 83.72,47.76 83.57,47.76 v4(83.35,47.54) 80.78,44.97 75.72,44.97 74.79,44.04 73.58,44.04 72.51,42.98 70.37,42.98 69.42,42.03 62.73,42.03 61.33,43.42 50.67,43.42 45.7,38.46 39.13,38.46 38.51,39.08 30.98,39.08 25.37,33.46 24.71,33.46 20.27,29.02 15.64,29.02 15.39,28.76 v2(15.39,27.68)
SD_CMD: length 108.4
  TOP w0.089: U1JSL.CG47 104.07,52.09 104.36,51.8 104.36,50.93 104.23,50.8 104.23,49.73 103.77,49.26 103.77,48.4 103.65,48.27 v2(103.65,47.68)
  TOP w0.109: R209.1 16.07,24.81 v2(16.17,24.7)
  BOTTOM w0.109: v2(103.65,47.68) 103.65,47.24 102.57,46.16 101.62,46.16 101.3,46.48 99.87,46.48 99.32,47.03 94.61,47.03 94.13,46.54 89.52,46.54 89.41,46.43 89.41,46.15 89.3,46.04 89.03,46.04 88.92,46.15 88.92,46.43 88.81,46.54 88.54,46.54 88.43,46.43 88.43,46.15 88.32,46.04 88.05,46.04 87.94,46.15 87.94,46.43 87.83,46.54 87.56,46.54 87.45,46.43 87.45,46.15 87.34,46.04 87.07,46.04 86.96,46.15 86.96,46.43 86.85,46.54 86.52,46.54 82.84,42.86 79.3,42.86 76.91,40.47 v4(76.73,40.47) 70.85,40.47 70.05,39.66 62.3,39.66 61.15,40.81 51.52,40.81 46.56,35.85 37.51,35.85 36.34,37.02 31.84,37.02 26.13,31.3 25.4,31.3 21,26.91 18.38,26.91 v2(16.17,24.7)
SD_CMD_R: length 2.5
  TOP w0.109: R209.2 CR3.1 13.85,25.26 13.64,25.05 J9.3
SD_DATA0: length 108.2
  TOP w0.089: U1JSL.CJ47 103.77,52.29 103.77,51.94 103.61,51.58 103.56,51.47 103.56,50.86 103.68,50.75 103.68,49.97 102.52,48.81 v2(102.52,48.56)
  TOP w0.109: R205.1 15.68,28.33 16.15,27.86 v2(16.15,27.75)
  BOTTOM w0.109: v2(102.52,48.56) 102.52,48.48 101.62,47.58 100.55,47.58 99.97,48.16 99.26,48.16 99.16,48.27 99.16,48.99 99.05,49.09 98.9,49.09 98.8,48.99 98.8,48.26 98.7,48.16 98.54,48.16 98.43,48.27 98.43,48.99 98.33,49.09 98.18,49.09 98.07,48.99 98.07,48.68 97.96,48.58 97.81,48.58 97.71,48.68 97.71,48.99 97.6,49.09 97.45,49.09 97.34,48.99 97.34,48.68 97.24,48.58 97.09,48.58 96.98,48.68 96.98,48.99 96.87,49.09 96.72,49.09 96.62,48.99 96.62,48.68 96.51,48.58 94.13,48.58 93.77,48.22 91.99,48.22 91.51,47.74 86.17,47.74 82.49,44.05 77.82,44.05 v4(77.5,43.73) 76.79,43.02 75.59,43.02 75.15,42.58 73.68,42.58 72.91,41.8 70.59,41.8 69.59,40.8 62.72,40.8 60.95,42.57 51.05,42.57 45.42,36.94 38.22,36.94 37.01,38.16 31.34,38.16 25.72,32.55 25.04,32.55 20.55,28.05 16.45,28.05 v2(16.15,27.75)
SD_DATA0_R: length 2.5
  TOP w0.109: J9.7 13.78,28.65 13.88,28.75 14.37,28.75 14.41,28.78 CR1.1 R205.2
SD_DATA1: length 108.5
  TOP w0.089: v2(101.89,48.48) 101.89,48.61 102.77,49.48 102.77,50.1 103.08,50.41 103.08,50.74 103.28,50.94 U1JSL.CJ50
  TOP w0.109: R206.1 15.72,29.32 16.15,28.89 v2(16.15,28.51)
  BOTTOM w0.109: v2(16.15,28.51) 20.47,28.51 24.89,32.93 25.57,32.93 31.21,38.57 38.28,38.57 38.88,37.97 45.93,37.97 50.9,42.93 61.1,42.93 62.85,41.18 69.33,41.18 70.62,42.47 72.8,42.47 73.83,43.5 v4(75.58,43.5) 76.57,43.5 77.55,44.48 82.4,44.48 82.85,44.93 82.85,45.08 82.29,45.64 82.29,45.79 82.4,45.89 82.55,45.89 83.1,45.34 83.25,45.34 83.36,45.44 83.36,45.59 82.8,46.15 82.8,46.3 82.91,46.41 83.06,46.41 83.62,45.85 83.77,45.85 83.88,45.96 83.88,46.11 83.32,46.67 83.32,46.82 83.42,46.92 83.57,46.92 84.13,46.36 84.28,46.36 86.02,48.1 91.36,48.1 91.84,48.58 93.38,48.58 94.25,49.46 99.34,49.46 99.52,49.27 99.52,48.63 99.61,48.54 99.81,48.54 99.9,48.63 99.9,49.08 99.99,49.17 100.26,49.17 100.67,48.77 100.67,48.13 100.84,47.96 101.39,47.96 101.89,48.45 v2(101.89,48.48)
SD_DATA1_R: length 2.6
  TOP w0.109: J9.8 13.82,29.55 14.04,29.77 CR6.1 R206.2
SD_DATA2: length 107.7
  TOP w0.089: U1JSL.CG49 103.76,51.47 103.76,50.92 103.85,50.82 103.85,49.87 103.14,49.16 v2(103.14,48.56)
  TOP w0.109: R207.1 16.08,22.78 v2(16.14,22.84)
  BOTTOM w0.109: v2(103.14,48.56) 101.78,47.2 100.4,47.2 99.83,47.78 97.78,47.78 97.36,48.19 94.61,48.19 93.68,47.27 86.22,47.27 82.61,43.66 78.12,43.66 77.04,42.58 v4(76.6,42.58) 75.82,42.58 75.37,42.13 73.9,42.13 73.2,41.42 70.74,41.42 69.74,40.42 62.58,40.42 60.79,42.21 51.21,42.21 45.58,36.58 38.04,36.58 36.84,37.78 31.51,37.78 25.9,32.17 25.19,32.17 20.66,27.64 17.9,27.64 15.32,25.06 15.32,23.6 16.11,22.81 16.11,22.81 v2(16.14,22.84)
SD_DATA2_R: length 2.5
  TOP w0.109: R207.2 CR5.1 14.05,23.23 14.03,23.25 J9.1
SD_DATA3: length 107.8
  TOP w0.089: U1JSL.CG51 104.05,49.81 103.57,49.33 103.57,48.44 103.05,47.93 v2(103.05,47.58)
  TOP w0.109: R208.1 15.87,23.79 v2(16.15,24.06)
  BOTTOM w0.109: v2(16.15,24.06) 15.7,24.51 15.7,24.9 18.07,27.27 20.83,27.27 25.35,31.79 26.05,31.79 31.67,37.4 36.62,37.4 37.81,36.21 45.74,36.21 51.37,41.84 60.64,41.84 62.44,40.04 69.89,40.04 70.84,40.99 74.23,40.99 74.83,41.59 77.04,41.59 v4(77.9,42.45) 78.71,43.26 82.72,43.26 86.37,46.91 93.97,46.91 94.57,47.5 94.82,47.5 94.93,47.39 95.12,47.39 95.23,47.5 95.23,47.7 95.34,47.81 95.54,47.81 95.64,47.7 95.64,47.5 95.75,47.39 95.95,47.39 96.06,47.5 96.06,47.7 96.17,47.81 96.36,47.81 96.47,47.7 96.47,47.5 96.58,47.39 96.78,47.39 96.89,47.5 96.89,47.7 97,47.81 97.19,47.81 97.3,47.7 97.3,47.5 97.41,47.39 99.47,47.39 100.02,46.84 101.45,46.84 101.77,46.53 102.42,46.53 103.05,47.16 v2(103.05,47.58)
SD_DATA3_R: length 2.5
  TOP w0.109: J9.2 13.93,24.15 14.02,24.24 CR4.1 R208.2
SD_ILIM: length 0.9
  TOP w0.109: R288.1 18.9,27.73 18.92,27.75 U34.2
SLP_S0_L: length 106.4
  TOP w0.079: U17.B6 150.31,24.02 148.75,24.02 v1(148.32,24.45)
  TOP w0.109: 91.41,53.21 93,54.79 R39.1 ; 89.38,49.75 89.38,50.15 90.19,50.96
  TOP w0.117: v2(89.38,49.61) 89.38,49.75 ; 91.41,53.21 v4(90.19,51.98) 90.19,50.96
  IN2 w0.097: v1(148.32,24.45) 147.55,25.21 141.6,25.21 140.87,24.47 138.96,24.47 136.75,22.26 134.78,22.26 133.99,21.47 133.99,20.58 133.69,20.28 131.21,20.28 130.82,19.88 125.17,19.88 124.68,20.38 117.59,20.38 116.3,21.67 107.24,21.67 107.14,21.76 95.86,21.76 94.28,23.35 89.21,23.35 88.12,24.44 88.12,25.73 82.67,31.18 82.67,45.33 86.95,49.61 v2(89.38,49.61)
SLP_S3_L: length 320.7
  TOP w0.079: U17.K12 155.84,28.25 155.97,28.38 155.97,28.73
  TOP w0.109: v2(59.89,68.13) 60.01,68.13 60.42,67.73 60.42,66.89 60.62,66.69 62.83,66.69 63.2,67.05 Q24.2 63.2,67.69 63.65,68.13 65.45,68.13 D35.1 ; D39.1 174.33,60.72 v2(175.41,59.65) ; R18.1 96.33,46.51 93.7,46.51 93.65,46.46 ; v2(165,76.13) 165.12,76.25 165.12,76.54 165.49,76.92 D40.1 ; v1(155.21,30.52) 155.21,29.91 155.97,29.14 155.97,28.73
  TOP w0.117: v2(89.55,42.15) 88.53,43.17 88.53,44.17 88.17,44.54 88.17,45.92 88.86,46.62 D33.1 89.37,47.36 90.95,47.36 91.2,47.1 91.2,46.67 91.42,46.46 93.65,46.46
  TOP w0.203: v2(59.49,32.48) 59.49,32.69 59.3,32.88 R203.1
  IN1 w0.114: v2(175.41,59.65) 175.92,60.17 176.2,60.17 176.75,59.62 176.75,58.71 178.12,57.34 179.66,57.34 182.09,54.91 182.09,51.96 182.35,51.7 182.35,42.63 184.21,40.78 184.21,34.7 183.91,34.4 182.46,34.4 182.11,34.06 166.75,34.06 165.98,33.29 165.98,32.77 165.63,32.41 163.06,32.41 162.07,31.42 156.11,31.42 v1(155.21,30.52)
  IN2 w0.097: v2(59.89,68.13) 59.17,68.85 54.96,68.85 54.48,68.36 54.48,67.52 53.57,66.62 46.96,66.62 46.54,66.2 46.54,65.8 41.76,61.02 41.76,57.4 v2(40.77,56.41) ; v2(165,76.13) 164.81,76.13 161.73,73.06 161.73,71.25 160.27,69.79 v2(159.38,69.79) ; v2(59.49,32.48) 59.19,32.79 52.73,32.79 49.49,36.03 49.49,43.17 48.6,44.05 42.73,44.05 v2(42.53,44.25)
  IN4 w0.089: v1(155.21,30.52) 155.21,30.11 154.23,29.12 150.65,29.12 150.17,28.64 150.17,26.85 147.06,23.74 147.06,23.08 146.09,22.11 145.2,22.11 144.98,21.88 144.98,21.58 145.05,21.5 145.05,21.07 144.93,20.94 144.93,20.03 143.4,18.5 138.74,18.5 137.51,19.73 123.09,19.73 122.21,18.86 113.56,18.86 v2(113.26,19.15)
  BOTTOM w0.114: 84.27,38.69 87.65,35.31 87.65,30.46 90.93,27.18 93.27,27.18 93.73,26.72 95.58,26.72 96.32,27.46 107.3,27.46 110.96,23.81 110.96,22.61 113.26,20.3 v2(113.26,19.15) ; 72.14,37.79 66.84,32.49 60.88,32.49 60.44,32.92 59.93,32.92 v2(59.49,32.48) ; v2(159.38,69.79) 159.45,69.71 159.45,67.45 161.19,65.71 172.58,65.71 173.36,64.93 173.36,63.56 173.69,63.23 173.69,60.45 174.49,59.65 v2(175.41,59.65) ; v2(40.77,56.41) 42.53,54.65 42.53,48.24 42.85,47.92 42.85,46.13 42.06,45.34 42.06,44.73 v2(42.53,44.25)
  BOTTOM w0.117: 84.27,40.88 80.3,40.88 77.2,37.79 72.14,37.79 ; 84.27,40.88 84.77,41.38 87.94,41.38 88.71,42.15 v2(89.55,42.15) ; 84.27,40.88 84.27,38.69
SLP_S4_L: length 141.2
  TOP w0.079: 148.81,25.76 149.6,25.76 149.72,25.64 U17.A9
  TOP w0.109: v2(95.72,46) 95.72,45.95 95.85,45.82 R19.1 ; v2(183.79,38.03) 183.79,37.43 184.22,36.99 185.31,36.99 185.91,37.59 D18.1 187.8,37.59 R1000.2 187.82,37.76 186.65,38.93 D1000.2 186.33,39.46 R465.2 ; v1(144.21,26.01) 144.26,26.01 144.51,25.76 148.81,25.76
  IN2 w0.097: v2(117.44,21.22) 118.09,20.58 124.78,20.58 125.27,20.08 130.72,20.08 131.12,20.48 133.59,20.48 133.79,20.68 133.79,21.57 134.68,22.46 136.61,22.46 138.84,24.69 140.77,24.69 141.71,25.63 143.84,25.63 v1(144.21,26.01)
  BOTTOM w0.114: v2(183.79,38.03) v4(183.79,35.88) 181.88,33.97 159.57,33.97 157.41,31.81 150.81,31.81 147.14,28.14 146.35,28.14 v1(144.21,26.01) ; v2(117.44,21.22) 114.98,21.22 107.86,28.35 93.39,28.35 89.35,32.38 89.35,40.43
  BOTTOM w0.117: v2(95.72,46) 95.72,45.11 93.34,42.73 92.06,42.73 91.78,42.45 91.78,42.29 91.02,41.53 90.46,41.53 89.35,40.43
SLP_SUS_L: length 204.9
  TOP w0.079: v1(154.21,21.42) U17.G2
  TOP w0.109: v2(50.58,66.05) 50.58,66.14 50.1,66.62 Q1010.2 49.48,66.92 49.59,67.04 50.42,67.04 50.69,67.31 50.69,68.39 50.3,68.78 D27.1 ; v2(90.97,26.15) 90.57,26.54 86.07,26.54 v2(85.65,26.12) ; v2(71.63,24.93) U32.4
  TOP w0.117: R10.1 v2(93.05,46)
  IN1 w0.097: v2(127.55,23.45) 125.07,20.98 125.07,18.2 125.57,17.7 146,17.7 149.19,20.89 151.66,20.89 152.67,21.91 153.72,21.91 v1(154.21,21.42)
  IN2 w0.097: v2(52.16,39.79) 51.97,39.99 51.97,45.86 46.87,50.96 46.87,55.97 47.95,57.05 47.95,59.57 51.4,63.03 51.4,64.76 50.58,65.58 v2(50.58,66.05) ; v2(93.05,46) 92.62,46.43 90.07,46.43 89.74,46.1 89.74,45.77 88.32,44.35 88.32,29.84 90.6,27.56 90.6,26.52 v2(90.97,26.15) 91.49,25.63 99.15,25.63 99.96,24.82 113.79,24.82 114.66,23.94 127.05,23.94 v2(127.55,23.45) ; v2(85.65,26.12) 84.66,25.13 78.44,25.13 76.76,23.45 73.32,23.45 71.85,24.93 v2(71.63,24.93)
  BOTTOM w0.114: D26.3 54.9,39.03 54.88,39.06 D36.1 52.9,39.06 v2(52.16,39.79)
  BOTTOM w0.117: D26.3 56.05,39.72 56.4,40.07 60.83,40.07 61.97,38.92 70.5,38.92 71.25,39.67 77.2,39.67 79.65,42.12 83.19,42.12 86,44.93 91.61,44.93 92.21,45.54 92.6,45.54 v2(93.05,46)
SNDW_RCOMP: length 5
  TOP w0.203: U1JSL.CR25 100.68,62.78 99.92,62.78 99.48,62.34 96.82,62.34 96.17,63 RT854.1
SRTC_RST_L: length 31.5
  TOP w0.089: 103.99,43.42 108.89,48.32 108.89,48.8 109.65,49.56 109.65,50.81 109.51,51.02 109.51,51.24 109.6,51.43 109.6,51.52 U1JSL.BR48
  TOP w0.109: 95.29,43.61 95.5,43.41 103.98,43.41 103.99,43.42
  TOP w0.117: 95.29,43.61 94.65,43.61 94.11,44.15 91.25,44.15 90.62,43.53 90.62,42.61 89.71,41.7 89.34,41.7 89.31,41.73 v4(88.87,41.73) 88.56,42.04 88.54,42.04 88.51,42.06 R3C22.2 88.2,42.47 87.97,42.7 C3C9.1 87.46,42.94 87.34,42.83 Q21.3
SUB_ANALOG: length 94.2
  TOP w0.109: Q23.1 154.13,15.09 v1(154.17,15.05) ; R284.2 125.05,19.86 124.28,19.09 v2(124.18,19.09)
  IN2 w0.097: v2(124.18,19.09) 125.37,17.9 135.67,17.9 137.95,20.18 145.03,20.18 v2(145.33,20.48)
  IN4 w0.089: v2(149.24,15.65) 149.24,15.72 149.93,16.41 151.13,16.41 152.49,15.05 v1(154.17,15.05) 154.17,16.42 155.78,18.03 158.2,18.03 160.27,15.96 161.77,15.96 162.28,16.48 178.03,16.48 182.9,21.35 182.9,24.41 184.15,25.66 185.15,25.66 188.93,29.44 v2(188.93,30.73)
  BOTTOM w0.114: J13.34 192.98,30.15 192.77,29.94 191.74,29.94 190.66,31.02 190.66,33.54 190.31,33.88 R204.2 190.02,33.46 188.93,32.37 v2(188.93,30.73) ; v2(145.33,20.48) 145.28,20.43 145.28,19.09 146.81,17.56 147.81,17.56 149.24,16.12 v2(149.24,15.65)
SUB_USB_C1_INT_ODL: length 139.5
  TOP w0.079: U17.E7 v1(152.91,24.02)
  TOP w0.109: D30.1 v2(82,15.43)
  IN1 w0.097: v2(98.52,16.71) 97.9,17.33 88.44,17.33 86.85,15.75 86.85,13.74 86.24,13.13 82.66,13.13 82,13.79 v2(82,15.43)
  IN4 w0.089: v2(98.52,16.71) 98.52,18.79 99.03,19.29 101.19,19.29 101.97,18.52 110.37,18.52 111.6,17.28 132.6,17.28 132.77,17.11 145.06,17.11 148.46,20.51 148.53,20.51 148.56,20.53 149.27,20.53 150.41,21.68 150.41,23.07 150.63,23.3 150.63,24.37 150.72,24.46 152.47,24.46 v1(152.91,24.02) 153.34,24.45 153.84,24.45 154.15,24.14 157.14,24.14 157.39,23.89 158.42,23.89 159.7,22.6 160.3,22.6 161.74,21.17 162.96,21.17 163.38,20.75 163.38,17.98 163.72,17.63 164.94,17.63 165.32,18.01 165.32,18.79 166.42,19.89 166.67,19.89 168.09,21.31 172,21.31 173.82,19.49 180.2,19.49 182.24,21.53 182.24,24.75 183.81,26.32 183.81,27.33 186.13,29.65 v2(187.72,29.65)
  BOTTOM w0.114: J13.35 v2(187.72,29.65)
SYS_RST_ODL: length 237.6
  TOP w0.079: U13.C1 164.55,19.04 164.55,18.59 164.67,18.47 v1(164.67,18.39) ; U17.H7 v1(154.86,24.67)
  TOP w0.089: v1(104.32,70.49) 104.57,70.24 U1JSL.CF9
  IN2 w0.097: v2(70.38,62.83) 70.38,64.2 71.33,65.15 74.47,65.15 82.92,73.6 85.37,73.6 85.51,73.75 89.27,73.75 89.43,73.59 93.62,73.59 95.01,72.2 95.65,72.2 95.98,72.53 99.42,72.53 102.88,69.07 103.65,69.07 103.93,69.35 103.93,69.7 104.32,70.08 v1(104.32,70.49) 105.25,71.43 105.25,72.58 105.77,73.1 129.36,73.1 130.29,74.03 133.1,74.03 133.54,74.47 135.39,74.47 136.04,73.82 138.05,73.82 144.93,80.7 165.54,80.7 167.49,78.76 176.02,78.76 185.09,69.69 185.09,53.36 185.78,52.67 186.64,52.67 186.86,52.45 186.86,51.67 185.79,50.61 185.79,48.91 184.51,47.62 184.51,46.92 v2(184.9,46.53)
  IN4 w0.079: v1(154.86,24.67) 154.86,24.54 155.09,24.32 156.99,24.32 157.27,24.6 158.49,24.6 158.7,24.38 158.7,24.17 158.77,24.1
  IN4 w0.089: 158.77,24.1 159.8,23.07 160.44,23.07 161.96,21.55 163.26,21.55 163.85,20.97 163.85,18.76 163.78,18.69 163.78,18.13 163.89,18.02 164.56,18.02 164.67,18.13 v1(164.67,18.39) 164.67,18.69 166.13,20.15 166.13,21.14 166.68,21.69 172.22,21.69 174.03,19.89 180.04,19.89 181.82,21.67 181.82,25.98 186.16,30.32 186.16,42.1 185.3,42.96 185.3,46.13 v2(184.9,46.53)
  BOTTOM w0.114: J15.6 79.94,61.87 79.01,62.8 78.65,62.8 75.33,59.47 73.6,59.47 70.38,62.69 v2(70.38,62.83) 70.35,62.83 C19.2 ; v1(104.32,70.49) 104.54,70.27 R403.2
TEMP_SENSOR_1: length 92.6
  TOP w0.079: U17.F2 153.24,20.82 153.56,20.5 153.56,20.33 153.49,20.26 153.49,20.03 153.25,19.8 153.13,19.8 v1(152.75,19.42)
  TOP w0.109: C128.1 155.82,17.95 155.43,18.34 154.6,18.34 153.95,18.98
  TOP w0.11: v1(152.75,19.42) 153.18,18.98 153.95,18.98
  TOP w0.117: R320.2 R321.1 89.9,33.08 89.31,33.08 88.93,32.7 v2(85.65,32.7)
  IN2 w0.097: v2(112.49,18.1) 113.08,18.1 116.11,15.07 143.16,15.07 148.34,20.25 151.83,20.25 152.66,19.42 v1(152.75,19.42)
  BOTTOM w0.114: v2(85.65,32.7) 87.13,31.22 87.13,30.58 91.69,26.03 104.07,26.03 105.23,27.19 107.17,27.19 110.71,23.64 110.71,18.89 111.5,18.1 v2(112.49,18.1)
TEMP_SENSOR_2: length 139.7
  TOP w0.079: v1(152.91,22.72) 152.91,22.07 U17.E3
  TOP w0.203: v2(141.04,73.77) 141.04,72.34 R323.1 R322.2
  IN1 w0.079: v1(152.91,22.72) 153.47,22.16 154.31,22.16 154.73,21.74 155.35,21.74 155.71,21.38
  IN1 w0.097: 155.71,21.38 156.26,20.83 161,20.83 161.33,21.17 163.9,21.17 165.45,19.63 167.44,19.63 167.75,19.32 170.43,19.32 171.62,20.5 172.96,20.5 174.62,22.16 175.21,22.16 177.56,24.51 181.8,24.51 189.33,32.04 189.33,40.46 189.76,40.88 189.76,56.74 178.71,67.79 178.71,74.2 178.04,74.86 174.99,74.86 174.1,75.75 174.1,76.25 v2(173.71,76.64)
  IN2 w0.097: v2(141.04,73.77) 141.47,73.34 143.02,73.34 144.93,75.25 144.93,77.22 147.49,79.78 163.01,79.78 165.47,77.32 173.26,77.32 173.71,76.88 v2(173.71,76.64)
  BOTTOM w0.114: C127.1 153.6,22.13 153.37,22.36 153.26,22.36 v1(152.91,22.72)
THRM_SET: length 3.3
  TOP w0.109: R91321.1 R91322.1 105.22,23.25 v4(104.9,23.57) U6581.1
TOUCH_INT_ODL: length 55.1
  TOP w0.089: v1(105.47,65.94) 105.8,65.61 U1JSL.CC19
  IN1 w0.097: v2(65.03,60.04) 65.19,59.88 75.74,59.88 78.27,62.4 82.79,62.4 83.3,61.89 83.84,61.89 84.74,62.79 84.74,63.57 87.17,66.01 91.98,66.01 92.24,65.75 92.7,65.75 v2(92.88,65.92)
  BOTTOM w0.089: v1(105.47,65.94) 104.9,65.37 103.4,65.37 103.18,65.15 102.26,65.15 101.79,65.62
  BOTTOM w0.114: v2(65.03,60.04) 65.46,60.48 65.46,60.86 62.96,63.36 60.52,63.36 60.11,62.95 60.11,62.47 60.25,62.33 J23.38 ; 101.79,65.62 100.21,65.62 100.11,65.72 99.59,65.72 99.5,65.64 97.92,65.64 96.74,66.81 94.81,66.81 94.29,66.29 93.25,66.29 v2(92.88,65.92)
TOUCH_RESET_L: length 52.1
  TOP w0.089: U1JSL.CE19 105.14,65.74 v1(104.93,65.94)
  IN1 w0.097: v2(65.04,60.64) 65.19,60.64 65.7,60.13 75.71,60.13 78.39,62.81 78.39,63.67 80.17,65.45 86.31,65.45 87.06,66.2 v2(92.32,66.2)
  BOTTOM w0.089: 101.77,66.07 102.49,65.35 103.08,65.35 103.31,65.58 104.57,65.58 v1(104.93,65.94)
  BOTTOM w0.114: v2(92.32,66.2) 92.66,66.54 94.17,66.54 94.69,67.06 99.98,67.06 100.51,66.54 100.51,66.44 v4(100.88,66.07) 101.77,66.07 ; v2(65.04,60.64) 62.58,63.1 60.7,63.1 60.47,62.87 60.47,62.47 60.75,62.19 J23.39
TOUCH_RPT_EN: length 59.3
  TOP w0.089: v2(98.44,59.61) 98.74,59.61 99.27,59.08 100.4,59.08 100.57,58.95 100.74,58.95 101.04,59.14 101.29,59.14 U1JSL.CN33
  IN1 w0.097: v2(98.44,59.61) 98.44,59.79 97.1,61.13 97.1,62.64 94.34,65.4 94.34,65.87 94.19,66.02 93.35,66.02 92.76,66.61 91.36,66.61 91.15,66.4 86.98,66.4 86.23,65.65 80.08,65.65 78.17,63.74 78.17,62.93 75.63,60.39 65.88,60.39 64.6,61.67 61.7,61.67 61.04,61.01 57.49,61.01 56.15,59.68 56.15,59.37 55.64,58.86 54.58,58.86 v2(53.92,59.52)
  BOTTOM w0.114: v2(53.92,59.52) 53.92,60.54 54.25,60.87 J23.26
TP_1: length 1.2
  TOP w0.089: U1JSL.BC13 114.65,67.68 v2(114.39,67.68)
  BOTTOM w0.114: TP41.1 114.21,67.86 v2(114.39,67.68)
TP_2: length 1.3
  TOP w0.089: U1JSL.BC15 114.45,67.2 v2(114.34,67.09)
  BOTTOM w0.114: TP40.1 113.91,66.68 114.32,67.09 v2(114.34,67.09)
TP_3: length 5.5
  TOP w0.089: U1JSL.CT49 100.14,51.65 99.48,52.3 97.68,52.3 97.09,52.89 95.67,52.89 TP43.1
TP_4: length 7.8
  TOP w0.109: TP42.1 94.58,52.69 96.84,52.69 98.96,50.57 100.29,50.57 100.35,50.64 U1JSL.CR52
TP_IST_0: length 2.5
  TOP w0.089: U1JSL.AW17 v2(117.34,66.03)
  BOTTOM w0.122: v2(117.34,66.03) 117.65,65.72 117.65,65.03 118.13,64.54 TP13.1
TP_IST_1: length 1.5
  TOP w0.089: U1JSL.AY17 116.58,66.02 v2(116.6,66.02)
  BOTTOM w0.114: TP12.1 117.11,66.53 v2(116.6,66.02)
TP_PCH_IST_0: length 1.3
  TOP w0.089: U1JSL.BK33 v2(112.02,59.49)
  BOTTOM w0.122: v2(112.02,59.49) 112.1,59.57 TP26.1
TP_PCH_IST_1: length 1.3
  TOP w0.089: U1JSL.BG33 v2(113.55,59.49)
  BOTTOM w0.122: v2(113.55,59.49) 113.55,60.05 TP25.1
TP_RSVD_1: length 1.5
  TOP w0.089: U1JSL.BP13 110.47,67.86 v2(110.83,68.23)
  BOTTOM w0.114: v2(110.83,68.23) 110.54,68.23 TP49.1
TP_RSVD_2: length 1.7
  TOP w0.089: v2(110.83,67.62) 110.83,67.59 110.44,67.2 U1JSL.BP15
  BOTTOM w0.114: v2(110.83,67.62) 110.65,67.62 TP50.1
TP_RSVD_3: length 6.5
  TOP w0.089: U1JSL.CC4 106.12,72.42 106.4,72.7 106.4,72.73 106.4,72.97 106.4,72.97 106.4,73.03 106.3,73.14 106.3,76.4 106.44,76.55 106.44,77.35 106.71,77.62
  TOP w0.109: 106.71,77.62 TP53.1
TP_RSVD_4: length 12.4
  TOP w0.089: U1JSL.BJ15 112.5,67.29 112.03,67.75 112.03,71.05 111.52,71.56 111.52,72.12 111.35,72.3 111.35,72.58 111.52,72.76 111.52,72.96 111.4,73.09 111.4,73.72 111.22,73.9 111.22,74.68 109.7,76.2 109.7,77.56 109.63,77.62
  TOP w0.109: 109.63,77.62 TP46.1
TP_RSVD_5: length 13.1
  TOP w0.089: 109.92,77.62 109.92,76.23 111.4,74.75 111.4,74.1 111.91,73.59 111.91,73.09 111.78,72.96 111.78,72.71 111.93,72.55 111.93,72.32 111.7,72.1 111.7,71.64 112.21,71.13 112.21,68.15 U1JSL.BJ13
  TOP w0.109: TP47.1 109.92,78.6 109.92,77.62
TP_RSVD_6: length 1.4
  TOP w0.089: U1JSL.AW18 v2(116.58,65.3)
  BOTTOM w0.114: v2(116.58,65.3) 116.9,65.3 117.06,65.14 TP37.1
TP_RSVD_7: length 1.8
  TOP w0.254: U1JSL.BP34 v2(110.5,58.08)
  BOTTOM w0.122: TP31.1 109.69,57.56 110.21,58.08 v2(110.5,58.08)
TP_RSVD_8: length 2.8
  TOP w0.254: U1JSL.BM34 v2(110.5,58.81)
  BOTTOM w0.122: v2(110.5,58.81) 109.94,59.36 109.94,59.84 110.33,60.22 TP32.1
TP_RSVD_9: length 1.6
  TOP w0.254: U1JSL.BT36 v2(108.98,58.06)
  BOTTOM w0.122: TP33.1 109.31,58.06 v2(108.98,58.06)
TP_RSVD_10: length 1.2
  TOP w0.089: U1JSL.BU15 v2(108.57,67.53)
  BOTTOM w0.114: v2(108.57,67.53) 108.76,67.53 TP28.1
TP_RSVD_11: length 1.2
  TOP w0.089: U1JSL.BW15 107.91,67.2 107.66,67.45 107.65,67.45 107.57,67.52 v2(107.56,67.52)
  BOTTOM w0.114: v2(107.56,67.52) 106.95,67.52 TP27.1
TP_RSVD_12: length 1.3
  TOP w0.089: v2(118.1,59.51) 117.74,59.15 U1JSL.AU33
  BOTTOM w0.122: v2(118.1,59.51) 118.33,59.74 TP29.1
TP_RSVD_13: length 2.9
  TOP w0.254: U1JSL.BT34 v2(108.98,58.79)
  BOTTOM w0.122: v2(108.98,58.79) 109.64,59.45 109.64,60.81 TP30.1
TP_RSVD_14: length 2.2
  TOP w0.089: U1JSL.AK17 v2(120.41,66.01)
  BOTTOM w0.122: TP23.1 120.79,64.62 120.79,65.62 v2(120.41,66.01)
TP_RSVD_15: length 1.3
  TOP w0.254: U1JSL.U33 v2(126.48,59.51)
  BOTTOM w0.122: TP24.1 126.94,59.97 v2(126.48,59.51)
TP_RSVD_16: length 1.7
  TOP w0.089: v1(123.43,66.09) 123.73,66.39 U1JSL.AC17
  BOTTOM w0.114: TP15.1 122.75,65.39 123.21,65.85
  BOTTOM w0.122: v1(123.43,66.09) 123.21,65.87 123.21,65.85
TP_RSVD_17: length 1.7
  TOP w0.089: U1JSL.AC18 123.31,65.16 v1(123.17,65.16)
  BOTTOM w0.114: TP14.1 123.17,64.71 v1(123.17,65.16)
TP_RSVD_18: length 1.4
  TOP w0.089: v2(121.15,59.51) 120.79,59.15 U1JSL.AK33
  BOTTOM w0.122: TP16.1 120.87,59.79 v2(121.15,59.51)
TP_RSVD_19: length 1.4
  TOP w0.254: U1JSL.U31 v2(126.47,60.18)
  BOTTOM w0.122: v2(126.47,60.18) 126.45,60.2 TP18.1
TP_RSVD_20: length 1.4
  TOP w0.254: U1JSL.V31 v2(125.69,60.13)
  BOTTOM w0.122: TP17.1 125.22,60.61 v2(125.69,60.13)
TP_RSVD_21: length 1.3
  TOP w0.089: U1JSL.AP33 119.26,59.15 v2(119.62,59.51)
  BOTTOM w0.122: TP20.1 119.6,59.54 v2(119.62,59.51)
TP_RSVD_22: length 1.3
  TOP w0.089: v2(119.62,58.79) 119.26,58.43 U1JSL.AP34
  BOTTOM w0.122: TP19.1 119.58,58.83 v2(119.62,58.79)
TP_RSVD_23: length 1.6
  TOP w0.254: v2(125.7,63.11) 126,63.4 U1JSL.V23
  BOTTOM w0.122: TP22.1 124.97,62.38 v2(125.7,63.11)
TP_RSVD_24: length 1.6
  TOP w0.254: U1JSL.V25 126.1,62.7 v2(125.62,62.24)
  BOTTOM w0.122: v2(125.62,62.24) 125.76,62.38 TP21.1
TP_RSVD_25: length 5.6
  TOP w0.109: U1JSL.AR1 118.37,73.35 118.37,74.05 118.22,74.2 118.22,75.87 118.35,76.01 118.35,77.28 117.95,77.69 117.95,78.26 TP52.1
TP_RSVD_26: length 1.8
  TOP w0.254: v2(109.37,56.61) U1JSL.BT38
  BOTTOM w0.122: v2(109.37,56.61) 108.67,57.3 TP51.1
TP_RSVD_28: length 4.4
  TOP w0.088: U1JSL.A51 133.83,50.89 133.98,50.73 134.54,50.73 135.13,50.15 135.99,50.15 136.64,49.49 TP35.1
TP_RSVD_29: length 1.8
  TOP w0.088: v2(134.39,50.37) 134.29,50.48 133.51,50.48 U1JSL.B52
  BOTTOM w0.114: TP36.1 134.56,49.77 134.56,50.2 v2(134.39,50.37)
TP_RSVD_30: length 1.3
  TOP w0.089: U1JSL.BD33 v2(115.07,59.49)
  BOTTOM w0.122: TP44.1 115.02,59.54 v2(115.07,59.49)
TP_RSVD_31: length 1.2
  TOP w0.089: U1JSL.BE33 v2(114.31,59.49)
  BOTTOM w0.114: v2(114.31,59.49) 114.31,59.34 TP45.1
TP_RSVD_32: length 2.3
  TOP w0.089: U1JSL.AR17 v2(118.86,66.03)
  BOTTOM w0.122: v2(118.86,66.03) 119.24,65.65 119.24,64.9 TP54.1
TP_RSVD_33: length 1.2
  TOP w0.089: U1JSL.CE40 105.74,56.13 v2(105.74,56.12)
  BOTTOM w0.114: TP48.1 105.46,55.84 v2(105.74,56.12)
TP_RSVD_34: length 2.7
  TOP w0.089: U1JSL.BC10 114.55,68.9 v2(114.45,68.9)
  BOTTOM w0.114: TP38.1 113.96,70.42 113.96,69.93 114.45,69.45 v2(114.45,68.9)
TP_RSVD_35: length 1.7
  TOP w0.089: U1JSL.BC12 114.6,68.29 v2(114.42,68.29)
  BOTTOM w0.114: v2(114.42,68.29) 113.94,68.77 TP39.1
TRACKPAD_INT_ODL: length 132.3
  TOP w0.089: U1JSL.CR49 100.77,51.74 100.35,51.32 100.04,51.32 99.85,51.51 99.85,51.68 99.41,52.12 98.87,52.12 v2(98.49,51.74)
  IN2 w0.097: v2(158.27,30.52) 157.18,29.42 150.08,29.42 149.04,30.47 143.83,30.47 140,26.63 138.03,26.63 135.72,24.32 133.84,24.32 132.58,23.05 131.02,23.05 130.62,22.66 127.15,22.66 126.53,23.28 114.19,23.28 113.25,24.22 99.22,24.22 98.6,24.84 90.84,24.84 84.71,30.97 84.71,45.05 87.87,48.21 89.98,48.21 90.18,48.41 93.15,48.41 93.94,47.62 96.81,47.62 98.49,49.3 v2(98.49,51.74)
  BOTTOM w0.114: v2(158.27,30.52) 158.73,30.97 160.62,30.97 162.59,29.01 164.19,29.01 164.62,28.57 164.62,27.01 164.39,26.78 163.64,26.78 162.98,26.12 162.98,25.87 162.4,25.28 162.17,25.28 161.57,24.68 R199.2 161.49,24.29 161.6,24.18 161.6,23.43 161.65,23.38 J18.2
UART_AP_TX_DBG_RX: length 160
  TOP w0.079: 165.98,24.54 165.75,24.31 165.75,22.87 165.5,22.62 U13.E8
  TOP w0.089: U1JSL.CH15 103.55,67.65 v1(103.55,67.68)
  TOP w0.109: 165.98,24.54 166.01,24.56 TP7.1 165.75,25.29 v1(165.75,25.59)
  IN2 w0.097: v1(165.75,25.59) 165.68,25.59 164.81,24.73 164.29,24.73 163.83,24.27 163.83,23.96 164.1,23.68 164.1,22.47 163.92,22.29 163.92,19.44 163,18.52 159.21,18.52 157.69,17 155.15,17 154.95,17.19 151.36,17.19 150.69,16.52 146.96,16.52 143.8,13.36 113.91,13.36 110.06,17.21 106.65,17.21 105.66,16.22 105.21,16.22 v2(104.81,16.61)
  IN4 w0.089: v1(103.55,67.68) 103.19,68.03 102.79,68.03 102.63,67.88 102.63,67.12 102.05,66.53 102.05,64.12 101.87,63.94 100.73,63.94 99.01,62.22 97.48,62.22 96.16,60.89 96.16,59.75 95.9,59.5 94.28,59.5 90.45,55.67 83.92,55.67 82.58,54.33 82.58,50.33 84.08,48.83 84.08,29.07 84.75,28.4 84.75,24.95 87.64,22.06 91,22.06 92.72,20.34 97.15,20.34 v2(97.34,20.15)
  BOTTOM w0.114: v2(104.81,16.61) 105.09,16.89 105.09,18.63 104.13,19.58 97.9,19.58 v2(97.34,20.15)
UART_C2D2_TX_EC_RX: length 2.2
  TOP w0.109: U1.16 168.07,27.84 v4(167.79,28.13) 167.76,28.1 R102.1
UART_DBG_TX_AP_RX: length 159.9
  TOP w0.089: U1JSL.CF15 104.23,67.62 v1(104.23,67.68)
  TOP w0.109: R68.1 167.33,26.1 TP6.1 167.4,26.56 v2(167.15,26.81)
  IN2 w0.097: v2(105.41,16.61) 105.43,16.61 106.23,17.41 110.17,17.41 114.01,13.57 143.71,13.57 146.86,16.71 150.59,16.71 151.29,17.41 155.15,17.41 155.34,17.22 157.58,17.22 159.14,18.79 161.53,18.79 162.01,19.26 163,19.26 163.47,19.73 163.47,22.31 162.84,22.94 162.84,23.98 163.82,24.95 164.53,24.95 165.04,25.46 165.04,25.74 164.97,25.82 164.97,26.5 165.36,26.9 167.06,26.9 v2(167.15,26.81)
  IN4 w0.089: v1(104.23,67.68) 103.88,67.33 103.14,67.33 102.25,66.44 102.25,63.94 102,63.69 100.75,63.69 99.03,61.97 97.61,61.97 96.41,60.77 96.41,59.62 96.03,59.24 94.3,59.24 90.54,55.48 84.01,55.48 82.8,54.27 82.8,50.42 84.29,48.93 84.29,29.17 84.95,28.5 84.95,25.11 86.23,23.83 87.64,23.83 89.21,22.26 91.09,22.26 92.82,20.53 97.55,20.53 v2(97.93,20.16)
  BOTTOM w0.114: v2(105.41,16.61) 105.33,16.69 105.33,18.78 104.25,19.86 98.23,19.86 v2(97.93,20.16)
UART_DBG_TX_EC_RX: length 31.1
  TOP w0.079: U17.K2 156.21,20.71 156.61,20.71 156.81,20.51 156.81,20.18 v1(156.69,20.05)
  TOP w0.109: v2(166.85,27.95) 167.31,27.49 R102.2 ; R356.1 169.92,20.59 170.22,20.59 v1(170.25,20.56)
  IN4 w0.089: v1(156.69,20.05) 157.19,19.55 157.19,19.07 157.6,18.67 161.13,18.67 163.13,16.67 168.02,16.67 169.83,18.48 170.33,18.48 170.6,18.75 170.6,20.21 v1(170.25,20.56)
  BOTTOM w0.114: v1(170.25,20.56) 170.25,21.91 169.45,22.71 168.24,22.71 167.45,23.49 167.45,25.18 167,25.64 167,25.88 166.68,26.19 v4(166.68,26.24) 166.68,26.97 166.85,27.13 v2(166.85,27.95)
UART_DBG_TX_H1_RX: length 6.4
  TOP w0.079: 168.51,24.39 168.32,24.2 167.8,24.2 167.61,24.01 167.61,23.64 167.24,23.27 167.24,22.99 167.1,22.85 166.87,22.85 166.75,22.73 166.75,22.34 U13.H7
  TOP w0.109: 168.51,24.39 168.6,24.47 169.28,24.47 169.36,24.4 R67.1 169.56,24.44 169.56,25.26 169.91,25.6 U1.19
UART_EC_TX_DBG_RX: length 29.6
  TOP w0.079: U17.H3 v1(154.86,21.42)
  TOP w0.109: U1.23 171.91,25.55 172.15,25.31 172.15,24.65 172.61,24.19 172.61,22.66 173.12,22.15 173.12,20.97 172.18,20.03 172.18,19.26 171.39,18.48 170.73,18.48 v1(170.25,18.96) 169.81,18.96 R315.1
  IN4 w0.089: v1(170.25,18.96) 170.02,18.73 169.82,18.73 167.94,16.86 163.21,16.86 161.21,18.86 159.8,18.86 159.14,19.52 159.14,20.28 158.78,20.64 156.23,20.64 155.85,21.02 155.26,21.02 v1(154.86,21.42)
UART_EC_TX_H1_RX: length 2.2
  TOP w0.079: U13.J2 168.04,19.6 v4(168.55,19.09) 168.81,18.82 168.93,18.82 169,18.89
  TOP w0.109: 169,18.89 169.04,18.94 R315.2
UART_H1_TX_AP_RX: length 2.7
  TOP w0.079: 167.28,24.54 167.2,24.46 167.2,23.81 166.75,23.37 166.75,22.99 166.5,22.73 U13.G8
  TOP w0.109: R68.2 167.33,24.59 167.28,24.54
UART_H1_TX_DBG_RX: length 10
  TOP w0.079: U13.B9 163.85,23.25 163.85,23.43 163.76,23.52 v1(163.67,23.52)
  TOP w0.109: v2(170.31,25.12) 170.41,25.21 U1.20
  IN4 w0.089: v1(163.67,23.52) 163.76,23.52 164,23.28 167.34,23.28 167.77,22.85 169.11,22.85 170.02,23.76 170.02,24.83 v2(170.31,25.12)
UART_H1_TX_EC_RX: length 2.9
  TOP w0.079: 169,20 167.94,20 167.6,20.34 167.25,20.34 U13.H4
  TOP w0.109: 169,20 169.07,20 169.34,20.27 R356.2
UCAM_RST_L: length 3.8
  TOP w0.089: U1JSL.CP18 101,65.8 100.45,65.8 100.31,65.67 99.64,65.67 99.58,65.73 98.54,65.73 v2(98.16,66.1)
  BOTTOM w0.114: TP113.1 97.7,66.56 v2(98.16,66.1)
USB2_BT_N: length 118.6
  TOP w0.089: U1JSL.BW6 107.71,71.45 v2(107.71,71.56)
  IN1 w0.097: v2(82.97,25.63) 82.78,25.43 82.78,25.05 81.97,24.24 78.02,24.24 77.12,23.34 74.64,23.34 72.8,21.5 72.8,19.6 69.08,15.87 65.27,15.87 64.86,15.47 59.4,15.47 58.76,14.82 57.6,14.82 53.72,10.94 52.21,10.94 51.02,9.75 45.95,9.75 45.03,10.68 45.03,12.84 45.24,13.05 45.53,13.05 v2(45.72,13.24)
  IN4 w0.097: v2(107.71,71.56) 107.88,71.4 108.03,71.4 108.2,71.56 108.2,71.72 107.32,72.6 104.06,72.6 103.02,71.57 102.93,71.57 102.41,71.05 102.41,68.29 101.11,66.99 101.11,64.93 99.74,63.56 96.14,63.56 95.21,62.63 93.82,62.63 92.6,61.41 92.6,60.61 89.59,57.59 84.93,57.59 81.92,54.58 81.92,48.77 83.07,47.63 83.07,26.34 82.78,26.05 82.78,25.83 v2(82.97,25.63)
  BOTTOM w0.097: U4100.69 45.15,13.25 45.32,13.08 45.54,13.08 45.57,13.11 45.59,13.11 v2(45.72,13.24)
USB2_BT_P: length 118.6
  TOP w0.089: v1(108.45,71.08) 108.45,70.62 108.33,70.5 U1JSL.BW8
  IN1 w0.097: v2(82.37,25.63) 82.57,25.43 82.57,25.13 81.89,24.45 77.94,24.45 77.04,23.55 74.56,23.55 72.6,21.59 72.6,19.68 68.99,16.08 65.18,16.08 64.78,15.67 59.32,15.67 58.67,15.03 57.52,15.03 53.63,11.15 52.13,11.15 50.94,9.96 46.04,9.96 45.23,10.77 45.23,12.76 45.32,12.85 45.52,12.85 v2(45.72,12.65)
  IN4 w0.097: v1(108.45,71.08) 108.4,71.13 108.4,71.81 107.4,72.81 103.97,72.81 102.93,71.77 102.84,71.77 102.2,71.13 102.2,68.37 100.91,67.08 100.91,65.02 99.65,63.77 96.06,63.77 95.12,62.83 93.74,62.83 92.4,61.49 92.4,60.69 89.5,57.8 84.85,57.8 81.72,54.67 81.72,48.69 82.86,47.54 82.86,26.43 82.57,26.14 82.57,25.83 v2(82.37,25.63)
  BOTTOM w0.097: U4100.70 45.16,12.75 45.31,12.9 45.47,12.9 v2(45.72,12.65)
USB2_ID: length 2.6
  TOP w0.089: U1JSL.CC6 106.17,71.21 v2(105.85,71.54)
  BOTTOM w0.114: v2(105.85,71.54) 105.85,72.34 v4(106.19,72.68) 106.14,72.73 R595.1
USB2_RCOMP: length 5.4
  TOP w0.089: U1JSL.CC2 106.12,75.83 106.11,75.84 106.11,76.54 106.12,76.55 R5F9.1
  TOP w0.109: R5F9.1 106.12,77.84 v4(105.84,78.12)
USB2_UFC_N: length 70.4
  TOP w0.089: v1(107.56,69.07) 108,68.63 U1JSL.BW12
  IN1 w0.097: v1(107.56,69.07) 107.51,69.12 106.99,69.12 106.84,68.97 103.02,68.97 102.94,68.9 101.4,68.9 100.49,69.81 99.22,69.81 98.79,70.25 96.97,70.25 96.83,70.1 96.16,70.1 95.76,70.5 93.6,70.5 92.82,71.28 91.08,71.28 90.44,70.65 86.09,70.65 84.6,69.16 78.01,69.16 75.84,66.99 74.27,66.99 73.52,66.24 73.26,66.24 72.27,65.25 67.69,65.25 67.41,64.97 65.96,64.97 65.94,64.98 54.86,64.98 53.99,64.12 52.36,64.12 52.09,63.85 52.09,62.8 50.97,61.68 48.84,61.68 47.04,59.88 46.54,59.88 46.3,60.12 46.3,60.34 v2(46.12,60.51)
  BOTTOM w0.097: J23.10 46.25,61.04 46.37,60.92 46.37,60.76 v2(46.12,60.51)
USB2_UFC_P: length 70.3
  TOP w0.089: U1JSL.BW10 108,69.4 107.78,69.62 v1(107.57,69.62)
  IN1 w0.097: v2(46.75,60.51) 46.6,60.51 46.5,60.41 46.5,60.21 46.63,60.08 46.96,60.08 48.76,61.89 50.89,61.89 51.88,62.88 51.88,63.93 52.28,64.32 53.91,64.32 54.77,65.19 66.03,65.19 66.04,65.17 67.32,65.17 67.6,65.45 72.18,65.45 73.18,66.45 73.44,66.45 74.19,67.19 75.75,67.19 77.92,69.36 84.52,69.36 86,70.85 90.36,70.85 90.99,71.49 92.91,71.49 93.69,70.7 95.84,70.7 96.24,70.3 96.74,70.3 96.89,70.45 98.87,70.45 99.31,70.01 100.57,70.01 101.49,69.1 102.85,69.1 102.93,69.18 106.75,69.18 106.91,69.33 107.28,69.33 107.35,69.4 107.35,69.5 107.47,69.62 v1(107.57,69.62)
  BOTTOM w0.097: J23.11 46.75,61.02 46.56,60.83 46.56,60.71 v2(46.75,60.51)
USB2_VBUSSENSE: length 2.9
  TOP w0.089: U1JSL.CC7 106.1,70.55 v1(105.79,70.86)
  BOTTOM w0.114: v1(105.79,70.86) 105.32,71.33 105.32,72.08 R596.1
USB_A0_CHARGE_EN_L: length 162.8
  TOP w0.079: 150.66,19.13 150.9,19.37 150.9,20.04 151.29,20.42 U17.C1
  TOP w0.109: v2(32.15,57.43) 29.78,57.43 29.28,56.93 Q38.2 ; v1(152.61,18.21) 152.94,18.21 153.17,17.98 153.81,17.98 154.02,17.77 154.02,17.29 154.58,16.73 154.58,15.43 154.83,15.17 v1(154.83,15.05) ; v1(150.51,18.5) 150.66,18.65 150.66,19.13
  IN2 w0.097: v1(152.61,18.21) 150.8,18.21 v1(150.51,18.5)
  IN4 w0.089: v2(144.57,13.46) 110.81,13.46 109.77,14.5 105.24,14.5 104.67,13.93 95.26,13.93 94.83,14.36 87.18,14.36 86.47,15.07 86.47,15.82 84.98,17.31 71.97,17.31 67.71,21.57 67.71,27.49 59.97,35.24 58.7,35.24 57.71,36.23 52.47,36.23 44.84,43.86 40.18,43.86 39.98,44.05 39.98,45.14 39.78,45.34 39.19,45.34 35.32,49.21 35.32,53.52 32.38,56.47 32.38,57.2 v2(32.15,57.43)
  BOTTOM w0.114: v2(144.57,13.46) 144.88,13.15 152.93,13.15 v1(154.83,15.05)
