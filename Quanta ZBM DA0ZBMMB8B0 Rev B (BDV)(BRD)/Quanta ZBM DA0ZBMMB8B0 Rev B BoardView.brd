# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_D0_PCH_TX_WLAN_RX_P: length 123.6
  TOP w0.089: v2(106.66,55.29) 106.54,55.29 U1JSL.CC41
  IN1 w0.089: 100.42,49.11 100.44,49.11 100.45,49.12 100.78,49.12 101.08,49.42 103.46,49.42 105.03,50.99 105.48,50.99 107.2,52.71 107.2,54.92 107.02,55.1 106.84,55.1 v2(106.66,55.29)
  IN1 w0.097: v2(34.29,20.41) 35.06,19.63 35.06,11.46 37.59,8.94 51.37,8.94 52.56,10.13 54.06,10.13 57.67,13.74 60.2,13.74 60.57,14.11 64.7,14.11 65.64,15.05 69.4,15.05 73.61,19.26 73.61,21.17 74.97,22.53 81.55,22.53 83.79,24.77 83.79,29.92 85.44,31.57 85.81,31.57 86.1,31.27 86.44,31.27 86.69,31.53 86.69,32.11 86.29,32.52 86.29,32.71 86.69,33.12 86.69,33.5 86.29,33.9 86.29,34.05 86.69,34.45 86.69,34.76 86.45,35 84.54,35 84.41,35.13 84.41,35.4 84.65,35.63 85.03,35.63 85.22,35.83 85.22,36.26 85.86,36.89 86.47,36.89 86.69,37.12 86.69,37.74 86.29,38.14 86.29,38.61 86.69,39.01 86.69,39.53 86.46,39.76 86.12,39.76 85.98,39.9 85.98,40.19 86.11,40.31 86.47,40.31 86.69,40.53 86.69,40.86 86.38,41.17 86.38,41.4 86.69,41.71 86.69,42.09 86.45,42.33 86.08,42.33 85.98,42.42 85.98,42.71 86.16,42.89 86.47,42.89 86.69,43.11 86.69,43.9 89.23,46.43 96.43,46.43 99.11,49.11 100.42,49.11
  BOTTOM w0.097: U4100.A21 34.63,20.75 v2(34.29,20.41)
CNV_D1_PCH_RX_WLAN_TX_N: length 90.8
  TOP w0.089: v2(104.75,53.42) 104.75,53.55 104.65,53.66 104.4,53.66 104.25,53.51 U1JSL.CG46
  IN1 w0.089: 100.42,51.57 100.44,51.57 100.45,51.56 101.18,51.56 101.37,51.38 103,51.38 103.91,52.28 103.91,52.85 104.28,53.22 104.61,53.22 104.75,53.37 v2(104.75,53.42)
  IN1 w0.097: 100.42,51.57 100.14,51.57 99.81,51.24 98.03,51.24 96.48,49.69 94.23,49.69 93.69,49.16 88.98,49.16 83.17,43.34 83.17,37.2 81.36,35.39 74.81,35.39 73.31,33.89 73.31,32.68 70.13,29.5 67,29.5 65.79,30.71 63.7,30.71 60.69,33.72 49.63,33.72 42.55,26.64 42.55,21.03 43.27,20.31 43.44,20.31 v2(43.82,19.92)
  BOTTOM w0.097: v2(43.82,19.92) 43.77,19.92 43.44,20.25 U4100.A37
CNV_D1_PCH_RX_WLAN_TX_P: length 90.8
  TOP w0.089: U1JSL.CG44 104.65,53.92 v2(104.75,54.03)
  IN1 w0.089: v2(104.75,54.03) 105.12,53.66 105.12,53.25 104.92,53.05 104.36,53.05 104.09,52.77 104.09,52.21 103.07,51.2 101.29,51.2 101.11,51.38 100.45,51.38 100.44,51.37 100.42,51.37
  IN1 w0.097: v2(43.82,20.51) 43.35,20.51 42.75,21.11 42.75,26.55 49.71,33.51 60.6,33.51 63.61,30.5 65.71,30.5 66.92,29.3 70.21,29.3 73.51,32.6 73.51,33.81 74.9,35.19 81.44,35.19 83.37,37.12 83.37,43.26 89.06,48.95 93.77,48.95 94.31,49.49 96.56,49.49 98.11,51.04 99.9,51.04 100.23,51.37 100.42,51.37
  BOTTOM w0.097: U4100.A36 43.58,20.75 v2(43.82,20.51)
CNV_D1_PCH_TX_WLAN_RX_N: length 125.2
  TOP w0.089: v2(107.56,55.95) U1JSL.BY39
  IN1 w0.089: v2(107.56,55.95) 107.73,55.78 107.92,55.78 108.1,55.59 108.1,54.42 108.98,53.54 108.98,52.64 108.85,52.5 108.85,52.38 108.86,52.36 108.86,52.34
  IN1 w0.097: 108.86,52.34 108.86,51.88 107.84,50.86 106.95,50.86 105.05,48.96 104.36,48.96 103.37,47.97 102.53,47.97 102.13,47.56 99.54,47.56 96.79,44.81 89.81,44.81 87.91,42.91 87.91,28.98 85.03,26.1 85.03,24.2 81.94,21.12 75.46,21.12 74.85,20.5 74.85,16.79 71.83,13.78 66.79,13.78 65.91,12.89 61.75,12.89 60.07,11.21 57.36,11.21 53.85,7.7 36.88,7.7 32.98,11.6 32.98,21.75 33.39,22.16 v2(34.21,22.16)
  BOTTOM w0.097: U4100.A24 34.91,22.25 34.82,22.16 v2(34.21,22.16)
CNV_D1_PCH_TX_WLAN_RX_P: length 125.2
  TOP w0.089: U1JSL.BY41 107.11,55.38 107.31,55.18 107.46,55.18 v2(107.56,55.29)
  IN1 w0.089: v2(107.56,55.29) 107.56,55.49 107.68,55.6 107.84,55.6 107.93,55.52 107.93,54.34 108.81,53.46 108.81,52.71 108.67,52.58 108.67,52.37 108.65,52.35 108.65,52.34
  IN1 w0.097: v2(34.19,21.58) 33.97,21.36 33.83,21.36 33.74,21.45 33.74,21.87 33.65,21.96 33.47,21.96 33.18,21.67 33.18,11.68 36.97,7.9 53.76,7.9 57.28,11.42 59.99,11.42 61.66,13.09 65.82,13.09 66.71,13.98 71.75,13.98 74.64,16.88 74.64,20.59 75.38,21.32 81.86,21.32 84.82,24.29 84.82,26.18 87.71,29.07 87.71,42.99 89.73,45.01 96.71,45.01 99.46,47.76 102.04,47.76 102.45,48.17 103.29,48.17 104.28,49.16 104.96,49.16 106.87,51.07 107.76,51.07 108.65,51.96 108.65,52.34
  BOTTOM w0.097: U4100.A23 34.97,21.75 34.74,21.97 34.59,21.97 34.4,21.79 34.4,21.69 34.29,21.58 v2(34.19,21.58)
CNV_RF_RST_L: length 129.8
  TOP w0.089: U1JSL.CJ49 103.46,51.82 102.99,51.34 102.99,50.9 102.9,50.81 102.9,50.49 102.59,50.17 102.59,49.56 101.99,48.96 101.62,48.96
  TOP w0.109: v2(95.65,50.61) 95.55,50.51 R384.1 95.55,48.95 95.92,48.58 100.73,48.58 101.11,48.96 101.62,48.96
  IN1 w0.097: v2(86.93,25.23) 87.03,25.23 88.75,23.51 v2(88.75,19.58)
  IN2 w0.097: v2(95.65,50.61) 95.65,52.26 93.62,54.29 89.93,54.29 88.92,55.31 83.58,55.31 81.3,53.02 81.3,31.66 86.93,26.03 v2(86.93,25.23) ; v2(88.75,19.58) 86.02,19.58 84.14,17.7 79.01,17.7 77.72,18.99 71.95,18.99 60.36,30.58 52.86,30.58 50.53,28.25 46.36,28.25 44.48,26.37 44.48,17.53 v2(44.03,17.08)
  BOTTOM w0.114: U4100.A42 43.27,17.75 43.94,17.08 v2(44.03,17.08)
CNV_RGI_DT: length 121.9
  TOP w0.109: v2(44.04,18.25) 44.8,19 44.8,25.17 v2(46.02,26.4)
  IN1 w0.097: v2(46.02,26.4) 46.42,26.79 46.42,27.32 47.23,28.13 52.06,28.13 54.41,30.48 59.97,30.48 62.8,27.65 63.49,27.65 64.38,26.76 71.77,26.76 72.14,27.13 74.91,27.13 75.91,26.13 81.71,26.13 82.25,26.67 82.25,27.02 v2(81.86,27.41)
  IN4 w0.089: v2(81.86,27.41) 81.86,27.44 81.46,27.83 81.46,33.76 78.85,36.38 78.85,46.79 78.35,47.28 78.35,56.52 80.5,58.67 80.5,61.51 86.77,67.78 89.05,67.78 89.62,68.35 91.53,68.35 91.78,68.11 94.13,68.11 94.77,67.46 96.51,67.46 98.24,69.19 98.24,70.89 97.94,71.19 97.94,72.58 v2(98.32,72.96)
  BOTTOM w0.109: U4100.A40 43.29,18.75 43.79,18.25 v2(44.04,18.25) ; R6D84.2 98.18,73.45 98.55,73.82 R6D82.1 98.85,73.5 v2(98.32,72.96) 98.44,72.83 99.33,72.83 99.59,72.58 R6D85.2 99.74,72.31 100.22,71.84 100.22,71.51 100.4,71.33 100.96,71.33 101.57,70.73 101.93,70.73 102.66,71.46 R400.2
CNV_RGI_DT_R: length 1.2
  TOP w0.089: 102.63,72.1 102.76,72.1 v1(102.86,72.2)
  TOP w0.109: 102.63,72.1 U1JSL.CL4
  BOTTOM w0.114: v1(102.86,72.2) 103.11,71.95 R400.1
CNV_RGI_RSP: length 114.6
  TOP w0.089: U1JSL.CP7 100.29,70.59 100.04,70.59 99.84,70.79
  TOP w0.109: v2(98.39,71.54) 99,70.93 99.7,70.93 99.84,70.79 ; R118.2 42.32,18.1 42.1,18.32 42.1,24.3 46.09,28.3 47.35,28.3 v2(47.85,28.8)
  IN1 w0.097: v2(81.86,28.1) 81.19,27.44 81.19,27.31 80.74,26.86 76.25,26.86 75.28,27.84 71.8,27.84 71.43,27.47 65.26,27.47 64.31,28.41 63.02,28.41 60.28,31.15 54.12,31.15 51.86,28.89 49.26,28.89 48.91,29.24 48.29,29.24 v2(47.85,28.8)
  IN4 w0.089: v2(81.86,28.1) 82.03,28.28 82.03,33.52 79.08,36.47 79.08,46.9 78.57,47.41 78.57,56.19 82.82,60.45 82.82,63.51 86.86,67.55 89.15,67.55 89.73,68.13 91.43,68.13 91.69,67.88 94,67.88 94.63,67.24 96.61,67.24 98.47,69.1 98.47,71 98.39,71.08 v2(98.39,71.54)
CNV_RGI_RSP_R: length 2.7
  TOP w0.109: R118.1 43.01,18.1 43.45,17.66 v2(44.04,17.66)
  BOTTOM w0.114: U4100.A41 43.41,18.25 43.99,17.66 v2(44.04,17.66)
CNV_WT_RCOMP: length 6.6
  TOP w0.089: U1JSL.CL52 102.61,50.55 102.4,50.35 102.4,49.68 101.96,49.23 100.85,49.23
  TOP w0.25: 100.85,49.23 100.67,49.05 R3808.1
CPU_C10_GATE_L: length 278.2
  TOP w0.079: U17.J4 v1(155.51,22.07)
  TOP w0.089: v2(98.03,63.07) 98.03,63.2 98.13,63.3 98.13,63.3 98.5,63.68 99.95,63.68 100.04,63.76 100.31,63.76 100.5,63.61 100.78,63.61 100.96,63.72 101.09,63.72 101.28,63.68 101.41,63.68 U1JSL.CL22
  TOP w0.109: v2(173.72,76.01) 173.05,76.67 173.05,77.16 169.51,80.71 163.37,80.71 R455.1 ; v2(83.71,60.89) 83.71,60.39 v4(82.91,59.59) 82.32,58.99 U24.D2
  TOP w0.117: U26.D2 89.27,36.51 90.19,36.51 90.47,36.23 90.47,35.65 90.21,35.39 89.71,35.39 88.66,34.35 88.66,33.71 88.09,33.13 85.42,33.13 85.2,32.91 85.2,32.22 85.65,31.77 v2(85.65,31.18)
  IN1 w0.079: 149.75,22.41 149.88,22.41 150.39,22.92 150.39,23.3 150.77,23.69 153.81,23.69 154.07,23.43 154.07,22.92 154.6,22.39 155.18,22.39 v1(155.51,22.07)
  IN1 w0.097: 149.75,22.41 147.95,22.41 147.75,22.22 147.75,20.6 146.25,19.09 143.2,19.09 142.6,19.69 138.44,19.69 137.75,18.99 v2(137.65,18.99) ; v2(83.71,60.89) 83.97,60.89 85.54,62.46 85.54,63.14 87.57,65.17 91.6,65.17 93.36,63.41 93.36,60.89 v2(94,60.26) ; v2(173.72,76.01) 173.72,75.76 174.81,74.67 177.96,74.67 178.51,74.12 178.51,67.71 189.56,56.66 189.56,40.98 189.14,40.56 189.14,32.13 181.74,24.73 177.47,24.73 175.1,22.36 174.52,22.36 172.87,20.7 171.53,20.7 170.36,19.53 167.96,19.53 167.65,19.85 165.55,19.85 164.01,21.39 161.22,21.39 160.87,21.03 156.34,21.03 155.51,21.86 v1(155.51,22.07)
  IN4 w0.089: v2(137.65,18.99) 137.1,19.54 125.22,19.54 124.35,18.67 111.36,18.67 110.69,19.34 108.1,19.34 107.5,19.94 102.63,19.94 102.49,20.08 98.42,20.08 97.68,19.34 93.42,19.34 90.89,21.87 87.43,21.87 84.55,24.75 84.55,27.79 84.26,28.08 v2(84.26,28.1) 84.24,28.1 83.89,28.45 83.89,48.72 82.36,50.24 82.36,54.42 83.84,55.89 90.35,55.89 94,59.54 v2(94,60.26) 94.89,61.15 95.98,61.15 97.9,63.07 v2(98.03,63.07)
  BOTTOM w0.114: v2(85.65,31.18) 85.65,29.49 v2(84.26,28.1) ; v2(98.03,63.07) 98.33,62.77 99.51,62.77 99.81,63.07 R355.1
CPU_POPIRCOMP: length 7
  TOP w0.089: U1JSL.CK50 102.29,50.84 102.29,50.53 102.23,50.47 102.23,49.75 102.03,49.56 99.95,49.56
  TOP w0.25: R7D9.1 97.75,49.81 98.01,49.56 99.95,49.56
CPUPWRGD: length 8.1
  TOP w0.089: U1JSL.AM2 119.72,72.87 119.72,73.59 119.85,73.72 119.85,75.08 120.15,75.38 120.15,77.08 119.81,77.42 119.81,77.62
  TOP w0.109: TP59.1 119.04,79.27 119.3,79.01 119.3,78.53 119.81,78.01 119.81,77.62
CSI_RCOMP: length 4.3
  TOP w0.109: R46.1 117.91,76.83 118.15,76.59 118.15,76.09 118.02,75.95 118.02,74.1 118.14,73.98 118.14,73.35 118.03,73.24 U1JSL.AT2
DBG_PMODE: length 74.3
  TOP w0.089: 119.57,77.62 119.57,77.22 119.65,77.14 R5G69.1 119.74,76.91 119.93,76.71 119.93,76.69 119.97,76.65 119.97,75.46 119.67,75.16 119.67,73.8 119.54,73.67 119.54,73.07 119.45,72.97 119.45,72.58 U1JSL.AN3
  TOP w0.109: 119.57,77.62 119.57,77.92 119.06,78.43 119.06,78.92 118.6,79.38 118.6,80.87 117.8,81.66 117.32,81.66 116.02,82.97 113.71,82.97 113.48,83.2 113.48,84.09 113.76,84.36 114.04,84.36 114.19,84.52 v2(114.19,84.77)
  IN2 w0.097: v2(114.19,84.77) 114.19,84.39 113.89,84.09 110.89,84.09 108.54,81.75 95.37,81.75 93.84,80.22 88.33,80.22 84.74,76.63 83.25,76.63 82.67,76.05 79.04,76.05 74.62,71.63 74.62,70.53 74,69.91 72.1,69.91 v2(70.96,68.77)
  BOTTOM w0.114: J15.7 75.08,66.61 73.46,66.61 72.62,67.46 72.17,67.46 R37.1 70.96,68.67 v2(70.96,68.77)
DBG_SPI_FLASH_CLK: length 17.1
  TOP w0.109: U1.15 168.38,28.34 168.04,28.69 v2(168.04,29.99)
  IN4 w0.089: v2(176.93,20.93) 174.29,23.56 172.76,23.56 171.99,24.33 171.99,25.35 171.31,26.03 170.71,26.03 169.69,27.05 169.69,28.33 v2(168.04,29.99)
  BOTTOM w0.114: R78.1 177.06,21.06 v2(176.93,20.93)
DBG_SPI_FLASH_CS_L: length 8.3
  TOP w0.109: U1.8 171.91,30.63 172.16,30.87 172.77,30.87 172.89,31 172.89,31.57 173,31.68 175.55,31.68 175.68,31.55 175.68,31.16 175.59,31.08 175.35,31.08 175.19,31.24 v4(174.64,31.24) 173.38,31.24 173.28,31.13 R76.2
DBG_SPI_FLASH_MISO: length 14.9
  TOP w0.109: U1.12 169.66,30.19 169.22,30.63 v4(168.74,30.63) 167.65,30.63 167.28,31 167.28,31.76 167.53,32.02 168.63,32.02 168.76,32.15 176.44,32.15 177.18,31.41 v2(177.18,31.15)
  BOTTOM w0.114: v2(177.18,31.15) 177.18,31.34 177.09,31.43 R77.2
DBG_SPI_FLASH_MOSI: length 16.6
  TOP w0.109: v2(169.23,29.99) 169.06,29.81 U1.13
  IN4 w0.089: v2(169.23,29.99) 170.07,29.15 170.07,26.94 170.74,26.27 171.46,26.27 172.2,25.53 172.2,24.5 172.88,23.82 174.38,23.82 176.84,21.36 178.66,21.36 v2(179,21.02)
  BOTTOM w0.114: R79.1 v2(179,21.02)
DDR_A_0ZQ0: length 2.4
  TOP w0.109: v4(142.36,41.46) 142.49,41.33 R4305.1
  TOP w0.114: U4301.A5 144.59,41.33 R4305.1
DDR_A_0ZQ1: length 2.5
  TOP w0.109: R4306.1 142.75,43.69 v4(142.36,43.29)
  TOP w0.114: U4301.A8 144.63,43.69 R4306.1
DDR_A_1ZQ0: length 1.7
  TOP w0.089: U4401.A5 131.72,41.51 131.72,41.56
  TOP w0.109: R4405.1 131.72,41.56
DDR_A_1ZQ1: length 1.9
  TOP w0.109: 134.99,42.19 135.25,42.44 R4406.1
  TOP w0.117: 134.99,42.19 134.51,41.71 U4401.A8
DDR_B_0ZQ0: length 1.6
  TOP w0.114: U4601.A5 118.31,41.37 R4605.1
DDR_B_0ZQ1: length 1.5
  TOP w0.114: R4606.1 120.89,41.19 U4601.A8
DDR_B_1ZQ0: length 1.6
  TOP w0.089: U4701.A5 107.64,35.97 108.27,35.97
  TOP w0.109: R4705.1 108.27,35.97
DDR_B_1ZQ1: length 1.6
  TOP w0.114: U4701.A8 107.74,33.67 R4706.1
DDR_COMP_0: length 7
  TOP w0.088: 134.3,50.98 133.96,51.32 133.68,51.32 U1JSL.C49 ; v4(139.38,50.06) R3803.1
  TOP w0.089: 134.58,50.98 134.3,50.98
  TOP w0.13: 134.58,50.98 135.12,50.44 136.14,50.44 136.6,49.98 137.44,49.98 137.52,50.06 R3803.1
DDR_COMP_1: length 7.9
  TOP w0.088: 132.71,50.08 132.37,50.42 132.37,51 U1JSL.D50 ; R3809.1 137.42,47.67 v4(137.58,47.51)
  TOP w0.13: 132.71,50.08 133.99,48.8
  TOP w0.254: 133.99,48.8 134.34,48.45 135.91,48.45 136.32,48.04 137.14,48.04 R3809.1
DDR_COMP_2: length 7
  TOP w0.088: R3810.1 138.41,51.01 138.41,51.01 v4(138.52,51.01) ; 135.13,50.73 134.95,50.91 134.76,51.11 134.76,51.62 134.41,51.97 133.66,51.97 U1JSL.C48
  TOP w0.13: R3810.1 137.37,50.67 137.37,50.36 137.21,50.2 136.7,50.2 136.16,50.73 135.13,50.73
DDR_RESET_L: length 120.5
  TOP w0.089: U4701.T11 v1(98.18,31.51) ; U4601.T11 v1(123.76,31.67) ; U4401.T11 v1(137.31,31.7) ; U4301.T11 v1(154.75,46.44)
  TOP w0.109: 132.96,25.82 132.48,26.3 v1(132.48,26.35)
  TOP w0.114: 132.96,25.82 C4401.1 ; C4301.1 154.97,36.24 v1(154.91,36.24) ; C4601.1 v1(118.99,26.48)
  TOP w0.117: R3903.2 90.63,41.55 90.44,41.36 v2(90.44,40.91) ; C4701.1 90.19,31.52 90.53,31.87 v2(90.53,31.88)
  IN1 w0.089: 118.21,27.26 116.37,27.26
  IN1 w0.097: v1(154.91,36.24) 153.05,36.24 153.02,36.21 143.6,36.21 139.1,31.7 v1(137.31,31.7) 136.67,31.06 136.67,28.64 135.31,27.28 135.31,26.95 135.11,26.74 134.63,26.74 134.38,26.99 133.11,26.99 v1(132.48,26.35) 131.79,26.35 131.39,26.75 126.4,26.75 125.9,26.25 119.22,26.25 v1(118.99,26.48) 118.21,27.26 ; 116.37,27.26 109.47,27.26 107.99,28.74 99.63,28.74 97.76,30.61 97.76,31.1 v1(98.18,31.51)
  BOTTOM w0.114: v1(118.99,26.48) 118.6,26.09 118.6,25.7 119.13,25.17 120.76,25.17 121.76,26.17 121.76,27.06 122.55,27.85 122.55,28.69 123.34,29.48 123.34,31.25 v1(123.76,31.67) ; v1(154.75,46.44) 154.14,45.83 154.14,44.7 154.66,44.18 154.66,44.11 156.01,42.76 158.14,42.76 159.33,41.57 159.33,38.94 157.23,36.84 155.51,36.84 v1(154.91,36.24)
  BOTTOM w0.117: v1(98.18,31.51) 97.67,31 97.67,30.51 98.13,30.04 98.13,29.36 97.75,28.98 93.43,28.98 v2(90.53,31.88) 90.47,31.95 90.47,39.23 v4(89.91,39.79) 89.91,40.4 90.42,40.91 v2(90.44,40.91)
DEBUG_I2C_INA_SCL: length 2.4
  TOP w0.079: U13.J6 167.94,22.03 168.8,22.03 169,22.23
  TOP w0.109: R1023.1 169.34,22.57 169,22.23
DEBUG_I2C_INA_SDA: length 2.7
  TOP w0.079: U13.H6 167.25,21.35 167.66,21.35 167.94,21.63 v4(168.55,21.63) 168.79,21.86 169,21.86
  TOP w0.109: 169,21.86 169.04,21.86 169.16,21.98 R1024.1
DMIC0_CLK: length 73.2
  IN1 w0.097: v2(99.38,60.08) 99.38,59.93 98.65,59.19 97.33,59.19 96.16,60.36 96.16,60.9 95.79,61.28 95.27,61.28 94.89,60.89 94.89,60.01 94.25,59.37 91.84,59.37 91.08,58.61 88.16,58.61 87.9,58.86 87.23,58.86 86.89,59.21 85.44,59.21 84.75,59.9 82.67,59.9 81.27,58.49 79.79,58.49 77.53,56.24 75.97,56.24 71.61,51.88 60.94,51.88 60.49,52.34 54.81,52.34 53.66,53.48 45.79,53.48 45.36,53.91 45.36,54.93 45.64,55.21 v2(45.87,55.21)
  BOTTOM w0.109: J23.7 44.75,58.4 45.87,57.28 v2(45.87,55.21) ; v2(99.38,60.08) 99.79,59.68 100.12,59.68 100.75,60.31 C310.1 101.31,60.31 101.36,60.26 R389.2
DMIC0_CLK_R: length 3
  TOP w0.089: v2(104.15,60.72) 104.48,61.05 U1JSL.CF28
  BOTTOM w0.109: R389.1 102.27,60.08 103.01,60.08 103.25,60.33 103.75,60.33 v2(104.15,60.72)
DMIC0_DATA: length 8.5
  TOP w0.089: U1JSL.CH28 103.82,61.05 v2(103.49,60.72)
  BOTTOM w0.109: v2(103.49,60.72) 103.35,60.72 102.94,60.31 102.61,60.31 102.28,60.64 100.35,60.64 100.19,60.48 99.22,60.48 98.98,60.24 98.98,60.21 ; R397.1 97.62,60.04 97.97,60.04 v4(98.19,60.26) 98.34,60.11 98.88,60.11 98.98,60.21 ; 98.98,60.21 C313.1
DMIC0_DATA_R: length 70.2
  IN1 w0.097: v2(97.84,59.61) 97.42,59.61 96.54,60.49 96.54,61.06 95.94,61.66 95.09,61.66 94.51,61.07 94.51,60.16 94.09,59.75 91.66,59.75 90.9,58.99 88.31,58.99 88.06,59.24 87.33,59.24 86.87,59.71 85.62,59.71 84.95,60.38 82.87,60.38 81.73,61.51 80.61,61.51 79.9,60.81 79.9,59.37 77.26,56.73 75.79,56.73 71.43,52.38 61.13,52.38 60.68,52.82 55.09,52.82 53.37,54.53 51.43,54.53 51.19,54.29 46.2,54.29 v2(45.87,54.62)
  BOTTOM w0.109: v2(97.84,59.61) 97.78,59.61 97.32,59.15 R397.2 ; J23.6 44.25,58.11 45.33,57.03 45.33,55.05 45.75,54.62 v2(45.87,54.62)
DMIC1_CLK_R: length 2.6
  TOP w0.089: v2(103.48,61.69) 103.48,61.73 U1JSL.CH26
  BOTTOM w0.109: TP125.1 101.77,61.19 102.98,61.19 v2(103.48,61.69)
DMIC1_DATA: length 1.4
  TOP w0.089: U1JSL.CF26 104.48,61.97 v2(104.79,61.66)
  BOTTOM w0.109: TP126.1 104.34,61.66 v2(104.79,61.66)
DP_RCOMP: length 6.9
  TOP w0.089: 132.57,73.67 132.38,73.48 132.38,73.12 U1JSL.E3
  TOP w0.203: v4(137.79,73.75) 137.23,73.19 R6F1.1 135.17,73.19 134.54,73.82 132.73,73.82 132.57,73.67
DRAM_RESET_N: length 30.7
  TOP w0.089: U1JSL.BV41 v2(108.47,55.29)
  TOP w0.109: 90.54,40.22 v2(90.44,40.32)
  TOP w0.114: R3903.1 91.41,41.12 91.2,40.91 91.05,40.91 90.47,40.32 v2(90.44,40.32) ; 91.76,41.56 92.14,41.56 R3902.2 ; C314.2 90.54,40.22
  TOP w0.117: R3903.1 91.76,41.56
  BOTTOM w0.114: v2(108.47,55.29) 107.99,54.81 107.99,53.05 105.81,50.86 v4(105.56,50.86) 105.56,50.42 105.68,50.3 105.68,48.58 100.73,43.62 94.68,43.62 93.29,42.23 92.35,42.23 v2(90.44,40.32)
DSI_TE: length 6.4
  TOP w0.089: U1JSL.AA4 124.84,72.42 125.11,72.69 125.11,73.04 125.03,73.13 125.03,73.39 125.43,73.79 125.43,74.74
  TOP w0.109: TP34.1 126.26,76.95 125.49,76.19 125.49,75.12 125.43,75.06 125.43,74.74
EC_AP_DPWROK: length 91
  TOP w0.079: 157.24,28.55 157.37,28.42 157.37,28.33 156.86,27.83 156.86,27.32 U17.L11
  TOP w0.109: v1(156.28,30.52) 156.28,30.24 v4(157.24,29.27) 157.24,28.55
  IN2 w0.097: v2(91.79,43.45) 91.79,43.06 89.55,40.83 89.55,31.96 94.67,26.84 99.81,26.84 100.64,26.01 114.28,26.01 115.09,25.19 131.18,25.19 131.44,24.93 135.44,24.93 137.84,27.33 139.83,27.33 143.58,31.08 150.74,31.08 150.93,30.89 155.91,30.89 v1(156.28,30.52)
  BOTTOM w0.117: R468.1 92.55,44.86 92.11,44.43 92.11,43.82 91.79,43.5 v2(91.79,43.45)
EC_AP_MKBP_INT_L: length 183.6
  TOP w0.079: 158.79,22.41 158.17,22.41 157.83,22.75 156.19,22.75 U17.K4
  TOP w0.089: v1(104.29,69.53) 104.57,69.25 U1JSL.CF11
  TOP w0.109: 158.79,22.41 159.26,22.41 159.5,22.16 159.5,21.52 158.97,20.99 158.97,16.7 v2(159.33,16.34)
  IN2 w0.097: v1(104.29,69.53) 104.67,69.91 104.97,69.91 105.35,70.3 105.35,71.12 105.47,71.23 105.47,72.31 106.04,72.88 129.45,72.88 130.38,73.81 133.19,73.81 133.65,74.27 135.25,74.27 135.91,73.61 138.13,73.61 145.01,80.48 165.44,80.48 167.36,78.56 175.91,78.56 184.87,69.6 184.87,53.14 185.78,52.23 v2(186.43,52.23)
  IN4 w0.089: v2(186.43,52.23) 186.64,52.23 188.28,50.6 188.28,41.49 188.07,41.28 187.41,41.28 187.11,40.98 187.11,36.74 188.64,35.21 188.64,31.6 189.36,30.88 189.36,29.5 185.26,25.4 184.26,25.4 183.16,24.3 183.16,21.34 178.09,16.27 162.43,16.27 161.92,15.76 159.91,15.76 v2(159.33,16.34)
EC_AP_PCH_PWROK_OD: length 121.8
  TOP w0.079: U17.K9 v1(156.16,25.97)
  TOP w0.089: 95.36,43.97 95.43,43.97 95.79,43.61 103.93,43.61 108.71,48.39 108.71,48.88 109.47,49.63 109.47,50.76 109.32,50.98 109.32,51.47 U1JSL.BT50
  TOP w0.117: v2(90.29,46) 89.8,46 88.95,45.15 D33.2 88.86,44.35 88.99,44.22 R338.2 R339.2 90.65,43.94 91.13,44.43 94.25,44.43 94.7,43.97 95.36,43.97
  IN1 w0.097: v1(156.16,25.97) 156.21,26.02 156.21,27.21 155.71,27.71 150.67,27.71 150.13,27.18 148.97,27.18 148.52,27.64 145.32,27.64 143.26,25.58 140.8,25.58 138.67,23.45 133.6,23.45 132.78,22.64 130.34,22.64 129.73,23.25 129.73,23.74 129.53,23.94 128.93,23.94 v2(128.44,23.45)
  IN2 w0.097: v2(90.29,46) 88.54,44.26 88.54,29.9 91.08,27.37 91.08,26.65 91.89,25.83 99.27,25.83 100.08,25.02 113.87,25.02 114.74,24.14 127.75,24.14 v2(128.44,23.45)
EC_AP_PSYS: length 2
  TOP w0.079: U17.H9 154.86,25.97 155.19,25.97 v1(155.51,25.97)
  BOTTOM w0.114: v1(155.51,25.97) 155.95,25.52 R202.2
EC_AP_PWR_BTN_ODL: length 111.6
  TOP w0.079: 152.63,29.56 152.63,28.93 152.9,28.66 152.9,27.28 U17.F11
  TOP w0.089: U1JSL.BU48 108.59,51.98 108.59,51.98 108.49,51.83 108.47,51.66 108.51,51.5 108.49,51.37 108.38,51.18 108.38,50.95 108.45,50.73 108.45,50.51 108.18,50.24 108.18,48.61 103.72,44.16 97.96,44.16 TP78.1 97.36,44.76 95.57,44.76 95.24,45.09 94.73,45.09 94.45,45.37 v2(94.45,46)
  TOP w0.109: v1(152.63,30.03) 152.63,29.56
  IN2 w0.097: v2(94.45,46) 93.98,45.53 93.32,45.53 91.77,43.98 89.73,43.98 89.14,43.39 89.14,31.77 94.46,26.45 99.64,26.45 100.48,25.61 114.12,25.61 114.97,24.76 131.05,24.76 131.27,24.53 135.64,24.53 137.98,26.87 139.93,26.87 143.75,30.68 149.61,30.68 150.67,29.62 152.26,29.62 152.63,29.99 v1(152.63,30.03)
EC_AP_RSMRST_L: length 216.5
  TOP w0.079: U17.K10 156.15,26.6 156.53,26.6 156.86,26.94 156.86,27.06 157.04,27.24 157.3,27.24 157.39,27.33 158.15,27.33 158.3,27.49
  TOP w0.109: v1(158.51,27.7) 158.3,27.49 ; v2(92.58,26.47) 92.58,26.45 91.83,25.7 84.63,25.7 83.12,24.19 81.44,24.19 v2(81.09,23.85)
  TOP w0.117: RB6B1.1 91.53,45.75 91.78,46 v2(91.81,46)
  IN1 w0.097: v2(132.4,23.45) 133.07,24.12 138.5,24.12 140.55,26.17 143.01,26.17 145.07,28.23 148.76,28.23 149.22,27.77 149.89,27.77 150.01,27.89 150.01,28.43 150.72,29.14 152.93,29.14 153.15,28.92 157.3,28.92 v1(158.51,27.7) ; v2(67.71,62.04) 68.09,61.66 72.89,61.66 75.81,64.58 77.59,64.58 79.65,66.64 85.76,66.64 86.55,67.43 88.11,67.43 v2(88.94,68.26)
  IN2 w0.097: v2(132.4,23.45) 131.52,24.34 131.19,24.34 130.97,24.56 114.89,24.56 114.03,25.41 100.39,25.41 99.57,26.23 92.79,26.23 92.58,26.45 v2(92.58,26.47) 92.58,27.13 91.97,27.75 91.46,27.75 88.94,30.27 88.94,43.49 90.85,45.4 91.16,45.4 91.76,46 v2(91.81,46) ; v2(81.09,23.85) 80.93,24.01 77.66,24.01 76.9,23.25 73.13,23.25 71.94,24.44 71.57,24.44 60.53,35.48 58.45,35.48 57.42,36.52 55.04,36.52 52.66,38.9 52.66,40.69 52.16,41.18 52.16,46.36 47.28,51.24 47.28,55.82 48.45,56.99 48.45,59.34 51.83,62.72 51.83,64.17 52.22,64.56 65.19,64.56 v2(67.71,62.04)
  BOTTOM w0.114: v2(88.94,68.26) 88.81,68.13 R45.1
EC_AP_RTCRST: length 96.6
  TOP w0.079: v1(156.16,23.37) U17.K5
  TOP w0.109: Q21.2 84.53,42.86 84.53,41.51 Q20.2 84.53,40.57 84.53,39.76 84.98,39.31 v4(84.98,38.85) 85.66,38.17 v2(85.66,38.11)
  TOP w0.117: R9.1 85,43.63 Q21.2
  IN1 w0.079: 151.02,26.3 151.03,26.29 153.19,26.29 153.43,26.05 153.43,24.7 154.32,23.81 155.72,23.81 v1(156.16,23.37)
  IN1 w0.097: 151.02,26.3 150.72,26.3 150.36,25.94 147.37,25.94 146.96,25.53 145.52,25.53 144.33,24.33 142.49,24.33 140.32,22.15 134.48,22.15 133.89,21.57 133.89,20.6 133.59,20.31 131.68,20.31 129.33,22.66 v2(129.33,23.45)
  IN2 w0.097: v2(129.33,23.45) 128.93,23.05 127.37,23.05 126.74,23.69 114.36,23.69 113.43,24.61 99.49,24.61 98.87,25.23 91.04,25.23 85.12,31.15 85.12,37.5 85.66,38.04 v2(85.66,38.11)
EC_AP_SYS_PWROK: length 177.3
  TOP w0.079: v1(151.61,26.62) U17.D10
  TOP w0.089: v1(105.66,70.12) 105.88,69.89 U1JSL.CC9
  IN2 w0.097: v1(105.66,70.12) 106.24,70.7 106.24,71.7 107.19,72.66 129.55,72.66 130.47,73.58 133.28,73.58 133.75,74.04 135.17,74.04 135.82,73.39 138.22,73.39 145.08,80.25 165.32,80.25 167.21,78.37 175.78,78.37 184.64,69.5 184.64,51.12 185,50.77 185,48.41 184.31,47.72 184.31,46.53 v2(184.9,45.93)
  IN4 w0.089: v1(151.61,26.62) 151.61,27.44 151.88,27.71 156.85,27.71 157.5,28.36 159.35,28.36 159.87,27.84 159.87,26.11 161.84,24.14 162.17,24.14 162.36,23.94 162.36,23.17 163.65,21.88 172.47,21.88 174.26,20.09 179.94,20.09 181.59,21.74 181.59,26.08 185.97,30.46 185.97,41.99 184.9,43.06 v2(184.9,45.93)
EC_AP_USB_C0_HPD: length 128
  TOP w0.079: U17.M11 157.7,26.94 v1(157.75,26.99)
  TOP w0.089: U1JSL.CN29 100.91,60.65 99.08,60.65 98.96,60.53 97.09,60.53 v2(97.01,60.61) 96.65,60.61 R49.1
  IN1 w0.097: v1(157.75,26.99) 157.11,26.99 156.19,27.91 150.58,27.91 150.05,27.38 149.06,27.38 148.6,27.83 145.24,27.83 143.18,25.77 140.72,25.77 138.59,23.65 133.5,23.65 132.68,22.84 130.44,22.84 129.92,23.35 129.92,23.84 129.62,24.14 127.44,24.14 126.75,23.45 123.69,23.45 v2(121.6,21.37)
  IN4 w0.089: v2(121.6,21.37) 121.06,20.82 109.17,20.82 108.53,20.18 108.08,20.18 107.73,20.52 106.6,20.52 105.66,21.47 94.48,21.47 93.26,22.69 89.08,22.69 87.72,24.04 86.4,24.04 85.15,25.29 85.15,28.6 84.61,29.14 84.61,35.7 84.49,35.83 84.49,47.99 88.03,51.53 88.03,52.7 94.32,58.99 96.13,58.99 96.67,59.52 96.67,60.26 v2(97.01,60.61)
EC_AP_USB_C1_HDMI_HPD: length 125.7
  TOP w0.079: U17.M12 157.4,27.59 157.51,27.7 v1(157.98,27.7)
  TOP w0.089: U1JSL.CC36 v2(105.47,57.11)
  IN1 w0.097: v1(157.98,27.7) 157.57,28.11 153.31,28.11 152.99,28.43 152.99,28.64 152.68,28.95 150.8,28.95 150.2,28.35 150.2,27.81 149.97,27.58 149.14,27.58 148.68,28.03 145.16,28.03 143.1,25.97 140.64,25.97 138.51,23.85 133.4,23.85 132.61,23.05 131.9,23.05 v2(131.51,23.45)
  IN2 w0.097: v2(131.51,23.45) 131.11,23.45 130.52,22.86 127.28,22.86 126.65,23.49 114.27,23.49 113.35,24.42 99.34,24.42 98.72,25.04 90.94,25.04 84.93,31.06 84.93,44.64 88.1,47.82 90.15,47.82 90.53,48.19 92.98,48.19 93.95,47.22 96.71,47.22 100.35,50.86 100.35,55.56 101.24,56.45 102.13,56.45 102.51,56.83 102.89,56.83 102.96,56.75 103.7,56.75 104.06,57.11 v2(105.47,57.11)
  BOTTOM w0.117: v2(105.47,57.11) 105.63,56.95 R402.1
EC_AP_VCCST_PWRGD_OD: length 198.3
  TOP w0.079: v1(152.91,25.32) U17.F8
  TOP w0.109: R8608.2 112.15,84.1 R8607.2 112.19,84.72 v2(112.24,84.77)
  IN2 w0.097: v1(152.91,25.32) 153.08,25.32 153.43,25.67 153.43,26.87 152.93,27.37 149.16,27.37 147.74,28.79 146.58,28.79 145.7,29.67 144.16,29.67 140.26,25.77 138.33,25.77 136.08,23.52 134.18,23.52 132.92,22.26 131.41,22.26 131.02,21.87 126.66,21.87 126.06,22.46 120.05,22.46 119.53,21.94 v2(119.53,21.91)
  IN4 w0.089: v2(112.24,84.77) 111.86,85.15 111.28,85.15 109.77,83.63 103.44,83.63 103.11,83.96 94.77,83.96 93.32,82.51 87.37,82.51 84.3,79.44 78.38,79.44 72.67,73.73 72.67,70.81 71.34,69.48 71.34,68.18 71.44,68.08 71.44,65.97 71.7,65.71 71.7,63.21 72.47,62.45 72.47,54.78 75.94,51.31 75.94,47.02 77.2,45.76 77.2,36.78 74.93,34.51 74.93,28.2 73.09,26.37 73.09,24.59 74.53,23.15 76.68,23.15 77.57,22.26 83.36,22.26 84.85,20.78 90.1,20.78 92.18,18.69 92.18,16.54 92.5,16.22 93.37,16.22 93.96,16.81 96.25,16.81 97.04,16.02 102.07,16.02 103.09,17.04 109.8,17.04 111.02,15.82 114.18,15.82 v2(114.37,15.62)
  BOTTOM w0.114: v2(114.37,15.62) 115.02,16.27 115.02,19.14 116.65,20.77 118.39,20.77 v2(119.53,21.91)
EC_AP_WAKE_ODL: length 132.5
  TOP w0.079: v1(157.75,23.25) 157.43,23.25 157.3,23.38 156.83,23.38 U17.L5
  TOP w0.089: U1JSL.CB48 106.24,52.08 106.07,51.83 106.05,51.66 106.1,51.5 106.07,51.37 105.97,51.18 105.97,50.93 106.04,50.83 106.04,50.53 105.82,50.31 105.82,48.81 103.88,46.86 102.68,46.86 102.48,46.66 101.88,46.66 101.49,47.05 100.15,47.05 100.09,47
  TOP w0.109: 100.09,47 96.39,47 ; v2(89.86,49.95) 91.66,48.15
  TOP w0.117: 91.66,48.15 R404.2 91.93,48.13 92.07,48.27 92.93,48.27 94.21,47 96.39,47
  IN2 w0.079: 154.2,21.91 154.36,21.74 155.81,21.74 156.36,22.29 156.36,22.67 156.71,23.03 157.1,23.03 157.33,23.25 v1(157.75,23.25)
  IN2 w0.097: v2(103.65,22.91) 103.65,22.93 103.41,23.18 94.82,23.18 94.45,23.55 89.31,23.55 88.32,24.54 88.32,25.83 82.87,31.28 82.87,45.14 86.97,49.23 89.6,49.23 89.86,49.49 v2(89.86,49.95) ; 154.2,21.91 152.55,21.91 151.54,20.9 148.03,20.9 143.39,16.25 120.72,16.25 118.97,18 117.68,18 115.75,19.93 111.25,19.93 110.41,19.09 107.8,19.09 v2(107.33,19.56)
  BOTTOM w0.114: v2(103.65,22.91) 104.8,21.76 105.06,21.76 107.06,19.77 107.12,19.77 v2(107.33,19.56)
EC_BATTERY_PRES_ODL: length 67.3
  TOP w0.079: U17.F3 v1(152.91,21.42)
  IN4 w0.089: v2(96.05,16.41) 96.64,15.82 102.21,15.82 102.61,16.22 107.42,16.22 108.02,16.81 109.75,16.81 111.49,15.07 143.45,15.07 143.8,15.42 145.67,15.42 149.1,18.86 151.4,18.86 152.29,19.75 152.29,20.8 v1(152.91,21.42)
  BOTTOM w0.114: v2(96.05,16.41) 96.05,17.11 96.03,17.13 96.03,18.98 96.16,19.11 96.16,21.02 96.38,21.24 R379.1
EC_ENTERING_RW: length 16.5
  TOP w0.079: v1(162.07,21.98) 162.55,21.5 163.06,21.5 163.21,21.35 163.75,21.35 U13.B5 ; v1(152.26,26.62) U17.E10
  TOP w0.109: R72.1 161.63,21.54 v1(162.07,21.98)
  IN4 w0.079: 153.97,27.11 153.14,26.29 152.59,26.29 v1(152.26,26.62)
  IN4 w0.089: v1(162.07,21.98) 160.75,23.3 159.87,23.3 158.96,24.21 158.96,24.55 158.27,25.25 158.27,25.55 157.84,25.98 156.76,25.98 155.47,27.28 154.13,27.28 153.97,27.11
EC_GP_SEL_ODL: length 4.1
  TOP w0.079: v4(158.46,25.69) 158.18,25.97 156.82,25.97 U17.L9
  TOP w0.109: v4(158.46,25.69) 158.75,25.98 159.14,25.98 159.56,26.41 R142.2
EC_I2C_BATTERY_SCL: length 60.7
  TOP w0.079: U17.D4 v1(151.61,22.72)
  IN4 w0.089: v2(99.22,18.79) 99.41,18.59 99.41,18.2 99.83,17.78 110.04,17.78 111.33,16.49 132.23,16.49 132.42,16.3 145.31,16.3 148.79,19.77 149.63,19.77 151.61,21.75 v1(151.61,22.72)
  BOTTOM w0.079: R123.2 150.64,23.56 150.64,23.18 150.77,23.04 151.28,23.04 v1(151.61,22.72)
  BOTTOM w0.109: J14.4 98.6,18.47 98.92,18.79 v2(99.22,18.79)
EC_I2C_BATTERY_SDA: length 58.9
  TOP w0.079: U17.C4 v1(150.96,22.72)
  IN4 w0.089: v1(150.96,22.72) 151.34,22.33 151.34,21.87 149.52,20.04 148.68,20.04 145.2,16.57 132.53,16.57 132.34,16.76 111.44,16.76 110.15,18.04 99.95,18.04 99.68,18.31 99.68,18.56 v2(99.91,18.79)
  BOTTOM w0.079: v1(150.96,22.72) 150.53,22.72 150.39,22.86 R121.2
  BOTTOM w0.109: v2(99.91,18.79) 100.11,18.79 100.6,18.3 J14.3
EC_I2C_EEPROM_SCL: length 16.4
  TOP w0.079: U17.G9 154.17,25.92 154.58,25.92 154.86,26.2 154.86,28.15 154.7,28.31 154.7,28.73
  TOP w0.109: U12.6 161.69,27.73 161.43,27.47 161.33,27.47 161.31,27.49 161.28,27.49 161.26,27.51 160.81,27.51 160.54,27.78 160.54,28.52 160.4,28.65 159.81,28.65 159.69,28.53 R128.2 159.35,28.59 159.35,28.78 159.28,28.86 158.76,28.86 v4(158.51,28.61) 158.51,28.86 156.42,30.95 155.01,30.95 154.7,30.64 154.7,28.73
EC_I2C_EEPROM_SDA: length 14.4
  TOP w0.079: U17.H11 154.42,26.94 154.17,27.19 154.17,27.9 153.94,28.13 153.94,28.73
  TOP w0.109: 153.94,28.73 153.94,28.89 154.42,29.37 154.42,30.76 154.89,31.24 156.54,31.24 157.87,29.91 v4(158.51,29.91) 158.51,29.4 158.77,29.14 159.43,29.14 R126.2 159.69,29.12 159.86,28.94 160.52,28.94 160.83,28.64 160.83,27.9 160.93,27.8 161.14,27.8 161.19,27.85 U12.5
EC_I2C_SENSOR_SCL: length 115.8
  TOP w0.079: U17.F12 153.24,27.82 153.08,27.98 153.08,29.11
  TOP w0.109: R132.2 153.17,30.2 153.17,30.05 v1(153.18,30.03) 153.18,29.27 153.08,29.17 153.08,29.11
  IN1 w0.097: v1(153.18,30.03) 153.54,30.39 153.97,30.39 154.68,29.67 162.22,29.67 163.34,30.8 163.9,30.8 164.49,31.38 165.87,31.38 166.45,31.96 172.16,31.96 173.02,32.83 184.59,32.83 184.99,33.22 184.99,38.79 188,41.8 188,49.29 187.68,49.61 187.68,55.99 170.22,73.45 169.46,73.45 169.03,73.87 169.03,74.37 v2(168.85,74.55) 169.02,74.72 169.02,76.84 171.33,79.15 188.73,79.15 189.29,78.6 189.29,78.2 v2(189.46,78.03)
  BOTTOM w0.109: v2(168.85,74.55) 168.8,74.5 U15.13 ; J24.5 190.67,78.9 190.35,79.22 190.15,79.22 189.31,78.38 189.31,78.18 v2(189.46,78.03)
EC_I2C_SENSOR_SDA: length 116.7
  TOP w0.079: 153.3,28.89 153.24,28.82 153.24,28.13 153.59,27.77 153.59,26.58 U17.G10
  TOP w0.109: 153.3,28.89 153.51,29.09 153.51,29.83 v1(153.71,30.03) 153.71,30.06 153.64,30.13 R130.2
  IN1 w0.097: v2(188.87,78.03) 189.01,78.18 189.01,78.48 188.62,78.88 171.44,78.88 169.29,76.73 169.29,74.72 v2(169.46,74.55) 169.31,74.4 169.31,73.98 169.57,73.72 170.33,73.72 187.95,56.1 187.95,49.72 188.27,49.41 188.27,41.68 185.26,38.67 185.26,33.11 184.71,32.55 173.14,32.55 172.27,31.69 166.57,31.69 165.99,31.11 164.6,31.11 164.01,30.52 163.45,30.52 162.33,29.4 154.57,29.4 153.93,30.03 v1(153.71,30.03)
  BOTTOM w0.109: U15.14 169.3,74.39 v2(169.46,74.55) ; J24.4 190.54,79.7 190.35,79.51 190.03,79.51 189.03,78.5 189.03,78.19 v2(188.87,78.03)
EC_I2C_SUB_USB_C1_SCL: length 46.1
  TOP w0.079: 158.79,25.33 158.7,25.24 157.92,25.24 157.88,25.29 156.13,25.29 U17.K8
  TOP w0.109: 158.79,25.33 159.26,25.33 v1(159.44,25.51) 159.57,25.39 160.05,25.39 160.12,25.45 R137.2
  IN1 w0.097: v2(180.73,27.93) 180.88,27.77 180.88,27.44 180.62,27.17 177.37,27.17 174.31,24.12 173.71,24.12 172.76,23.17 170.03,23.17 169.45,22.59 165.51,22.59 163.63,24.47 162.82,24.47 162.67,24.31 161.54,24.31 160.48,25.37 159.59,25.37 v1(159.44,25.51)
  BOTTOM w0.109: R91365.2 159.01,25.94 v1(159.44,25.51) ; v2(180.73,27.93) 180.92,27.74 180.92,27.09 182.33,25.68 186.99,25.68 190.08,28.77 192.75,28.77 192.88,28.65 J13.37
EC_I2C_SUB_USB_C1_SDA: length 45.6
  TOP w0.079: 158.79,25.05 158.78,25.05 158.74,25.09 158.11,25.09 158.05,25.02 158.05,24.82 157.83,24.6 157.43,24.6 157.37,24.65 157.09,24.65 156.75,24.99 U17.L8
  TOP w0.109: 158.79,25.05 159.35,25.05 v1(159.44,24.96) 159.58,25.1 160.02,25.1 160.12,25 R134.2
  IN1 w0.097: v1(159.44,24.96) 159.52,25.03 159.52,25.03 159.58,25.09 160.37,25.09 161.42,24.04 162.78,24.04 162.94,24.2 163.51,24.2 165.4,22.31 169.56,22.31 170.15,22.9 172.88,22.9 173.82,23.84 174.43,23.84 177.48,26.9 180.73,26.9 181.16,27.32 181.16,27.71 v2(181.37,27.93)
  BOTTOM w0.109: v2(181.37,27.93) 181.2,27.76 181.2,27.21 182.45,25.96 186.87,25.96 189.96,29.06 192.8,29.06 192.89,29.15 J13.36 ; R91364.2 159.16,25.23 v1(159.44,24.96)
EC_I2C_USB_C0_SCL: length 186.3
  TOP w0.079: U17.J10 v1(155.51,26.62)
  TOP w0.109: U9.35 61.81,20.84 61.9,20.92 61.93,20.95 61.93,21.63 62.25,21.96 63.42,21.96 v2(63.93,21.45) 63.93,21.36 63.41,20.85 U9.31 ; U6.36 31.19,60.2 31.45,59.94 31.45,59.59 31.98,59.06 33.87,59.06 34.48,59.67 34.85,59.67 34.94,59.57 34.94,59.37 v2(34.82,59.24)
  IN1 w0.097: v2(112.67,19.18) 112.48,18.98 112.48,18.68 112.07,18.28 106.95,18.28 106.02,19.21 98.16,19.21 97.55,18.6 76.53,18.6 76.07,19.06 76.07,19.3 v2(75.84,19.54) ; v2(133.38,20.89) 133.16,21.11 133.16,21.93 133.9,22.68 138.97,22.68 141.12,24.82 143.98,24.82 145.18,26.03 146.67,26.03 147.18,26.54 148.55,26.54 148.66,26.43 150.46,26.43 150.98,26.95 155.31,26.95 155.51,26.74 v1(155.51,26.62)
  IN4 w0.089: v2(34.82,59.24) 35,59.06 35,58.94 34.81,58.75 34.63,58.75 34.24,58.36 34.24,57.66 34.5,57.41 34.5,56.04 36.61,53.93 36.61,53.56 38.06,52.11 38.48,52.11 41.25,49.34 43.89,49.34 50.98,42.25 61.73,42.25 63.01,40.97 69.61,40.97 70.92,39.66 70.92,37.4 72.47,35.85 72.47,31.65 71.71,30.89 71.71,28.42 70.02,26.73 70.02,23.13 72.57,20.58 75.74,20.58 76.05,20.26 76.05,19.76 v2(75.84,19.54) ; v2(133.38,20.89) 133.21,20.71 133.21,20.47 132.95,20.21 122.88,20.21 122.38,19.71 112.68,19.71 112.48,19.51 112.48,19.37 v2(112.67,19.18)
  BOTTOM w0.109: R140.2 155.35,26.46 v1(155.51,26.62) ; U7.3 34.7,59.13 v2(34.82,59.24) ; v2(63.93,21.45) 63.76,21.62 63.76,21.75 63.92,21.91 66.67,21.91 68.26,20.32 75.62,20.32 76.02,19.92 76.02,19.72 v2(75.84,19.54)
EC_I2C_USB_C0_SDA: length 190.5
  TOP w0.109: U9.34 62.21,21.52 62.37,21.67 63.12,21.67 v2(63.34,21.46) 63.34,21.18 63.01,20.85 U9.32 ; v2(35.45,59.24) 35.23,59.46 35.23,59.69 34.97,59.96 34.36,59.96 33.75,59.35 32.1,59.35 31.74,59.71 31.74,59.94 31.99,60.2 U6.38
  TOP w0.203: U17.M7 157.55,24.34 v1(157.63,24.27)
  IN1 w0.079: v1(157.63,24.27) 157.12,24.27 155.84,25.55 155.84,26.28 155.92,26.37 155.92,26.72 155.62,27.02
  IN1 w0.097: v2(76.48,19.54) 76.35,19.41 76.35,19.17 76.65,18.87 97.43,18.87 98.05,19.49 106.13,19.49 107.07,18.55 111.96,18.55 112.2,18.8 112.2,18.98 v2(112.01,19.18) ; v2(132.76,20.89) 132.89,21.01 132.89,22.05 133.79,22.95 138.86,22.95 141.01,25.1 143.86,25.1 145.07,26.3 146.55,26.3 147.07,26.82 148.66,26.82 148.77,26.7 150.35,26.7 150.87,27.22 155.42,27.22 155.62,27.02
  IN4 w0.089: v2(35.45,59.24) 35.27,59.06 35.27,58.83 34.92,58.48 34.74,58.48 34.51,58.25 34.51,57.77 34.77,57.52 34.77,56.16 36.88,54.04 36.88,53.68 38.18,52.38 38.59,52.38 41.36,49.6 44,49.6 51.09,42.51 61.84,42.51 63.12,41.24 69.72,41.24 71.18,39.77 71.18,37.51 72.74,35.96 72.74,31.54 71.98,30.78 71.98,28.31 70.29,26.62 70.29,23.24 72.69,20.84 75.85,20.84 76.32,20.37 76.32,19.71 v2(76.48,19.54) ; v2(112.01,19.18) 112.21,19.38 112.21,19.62 112.57,19.98 122.27,19.98 122.77,20.48 132.84,20.48 132.94,20.58 132.94,20.71 v2(132.76,20.89)
  BOTTOM w0.109: v1(157.63,24.27) 157.38,24.52 157.17,24.52 157.07,24.62 R139.2 ; U7.4 34.94,58.73 v2(35.45,59.24) ; v2(63.34,21.46) 63.48,21.59 63.48,21.87 63.81,22.19 66.79,22.19 68.37,20.61 75.74,20.61 76.3,20.04 76.3,19.72 v2(76.48,19.54)
EC_IN_RW_OD: length 163.3
  TOP w0.079: v1(163.21,23.81) 163.21,23.39 163.5,23.11 U13.A9
  TOP w0.089: v1(105.61,69.53) 105.89,69.25 U1JSL.CC11
  IN2 w0.097: v1(105.61,69.53) 105.92,69.21 106.94,69.21 107.1,69.38 107.1,71.54 107.97,72.4 129.65,72.4 130.58,73.33 133.39,73.33 133.89,73.82 135.04,73.82 135.69,73.18 138.28,73.18 145.11,80 165.26,80 167.09,78.17 175.62,78.17 184.4,69.39 184.4,51.43 184.18,51.21 184.18,49.52 v2(184.61,49.08)
  IN4 w0.089: v2(184.61,49.08) 184.61,47.67 184.31,47.37 184.31,43.04 185.57,41.77 185.57,30.71 181.07,26.2 181.07,21.79 179.81,20.53 176.62,20.53 174.07,23.09 169.8,23.09 169.37,22.66 167.65,22.66 167.21,23.09 163.45,23.09 163.21,23.33 v1(163.21,23.81)
  BOTTOM w0.089: R117.2 105.15,70.83 105.28,70.7 105.28,69.86 v1(105.61,69.53)
EC_KSI: length 26.5
  TOP w0.079: U13.A8 163.37,22.6 162.67,23.29 162.67,24.04 162.89,24.25 162.89,24.54
  TOP w0.109: v1(162.12,24.67) 162.14,24.65 162.35,24.65 162.68,24.98 R3003.1 162.89,24.54 ; R3004.1 v1(147.18,21.76)
  IN4 w0.079: 151.42,27.11 151.42,27.11 150.39,26.07
  IN4 w0.089: v1(162.12,24.67) 161.69,24.67 160.06,26.3 160.06,27.92 159.37,28.61 157.36,28.61 156.65,27.9 151.81,27.9 151.42,27.52 151.42,27.11 ; v1(147.18,21.76) 147.23,21.81 147.47,21.81 148.23,22.57 149.62,22.57 149.84,22.78 149.84,23.31 150.06,23.53 150.06,25.75 150.39,26.07
EC_KSI_02: length 23.9
  TOP w0.079: 148.42,22.38 148.56,22.52 149.55,22.52 149.68,22.39 U17.A4
  TOP w0.109: R27298.2 147.18,23.18 v1(148.33,22.03) 148.33,22.29 148.42,22.38 ; R3003.2 163.34,25.08 162.89,25.53 R3006.2 162.89,25.99 162.71,26.17 162.71,26.38 162.47,26.62 v1(162.47,26.83)
  IN2 w0.079: 150.54,23.53 150.69,23.69 156.49,23.69 156.99,24.19 156.99,25.59 157.37,25.97 158.48,25.97
  IN2 w0.097: 158.48,25.97 159.21,26.71 161.74,26.71 161.89,26.86 162.45,26.86 162.47,26.84 162.47,26.84 v1(162.47,26.83) ; 150.54,23.53 150.39,23.38 150.39,22.16 149.88,21.65 148.71,21.65 v1(148.33,22.03)
EC_KSI_03: length 7.1
  TOP w0.079: U17.B3 150.55,21.74 150.18,22.11 149.62,22.11 149.37,22.36 148.91,22.36 148.76,22.21 148.76,22.04
  TOP w0.109: 148.76,22.04 148.76,21.8 148.48,21.52 148.04,21.52 147.79,21.77 147.79,21.86 R27297.2 147.18,22.33 146.73,21.88 R3004.2 146.73,21.09 147.18,20.64 R3005.2
EC_KSO_02_INV: length 15.2
  TOP w0.079: v1(162.81,20.8) 162.81,20.93 162.97,21.1 U13.A5 ; U17.C5 v1(150.96,23.37)
  IN4 w0.079: v1(150.96,23.37) 151.28,23.69 154.05,23.69 154.07,23.71
  IN4 w0.089: 154.07,23.71 154.32,23.96 156.98,23.96 157.24,23.7 158.33,23.7 159.78,22.24 159.78,22.01 161.36,20.43 162.41,20.43 162.79,20.8 v1(162.81,20.8)
EC_PROCHOT_ODL: length 6.3
  TOP w0.079: 154.46,18.82 154.25,19.04 154.25,20.54 154.07,20.71 153.69,20.71 153.56,20.84 153.56,21.42 U17.G3
  TOP w0.109: 154.46,18.82 154.47,18.81 v4(155.04,18.81) 155.34,18.81 156.48,17.67 R145.1
EC_RST_ODL: length 72.1
  TOP w0.079: U17.J5 v1(155.51,22.72) ; U13.B3 163.74,19.84 163.12,19.84 163,19.96 161.78,19.96 v1(161.5,19.69)
  TOP w0.109: v2(105.56,26.48) 105.81,26.48 106.42,25.87 R91319.2
  IN2 w0.079: 154.22,22.39 155.19,22.39 v1(155.51,22.72)
  IN2 w0.097: v2(109.1,20.18) 109.4,20.48 115.54,20.48 117.82,18.2 119.07,18.2 120.82,16.45 143.22,16.45 145.87,19.1 145.87,19.86 146.83,20.81 147.58,20.81 147.87,21.1 151.35,21.1 152.42,22.16 153.82,22.16 154.05,22.39 154.22,22.39
  IN4 w0.079: v1(155.51,22.72) 156.05,22.72 156.36,22.41 156.36,21.87
  IN4 w0.089: 156.36,21.87 157.08,21.14 159.77,21.14 161.23,19.69 v1(161.5,19.69)
  BOTTOM w0.114: v1(155.51,22.72) 155.51,22.61 155.96,22.16 R423.1 ; v2(105.56,26.48) 105.56,24.34 109.1,20.79 v2(109.1,20.18)
EC_RST_R_L: length 2.3
  TOP w0.109: U6581.3 v4(105.05,25.47) 105.85,25.47 R91319.1
EC_SUB_ANALOG: length 6.7
  TOP w0.079: 152.17,18.82 152.01,18.98 152.01,19.72 152.32,20.03 152.32,20.82 U17.E2
  TOP w0.109: C249.1 152.87,16.06 152.81,16.12 152.81,16.58 153.21,16.98 R286.1 152.98,17.46 152.79,17.65 R285.1 152.38,17.65 152.17,17.85 152.17,18.82
EC_SUB_IO_2: length 5.6
  TOP w0.079: 149.4,20.39 149.43,20.39 149.75,20.71 150.13,20.71 150.51,21.09 U17.B2
  TOP w0.109: 149.4,20.39 149.37,20.39 148.58,19.59 148.58,19.08 147.86,18.36 TP107.1 C1025.1
EC_VSNS_PP3300_A: length 5.9
  TOP w0.079: 151.07,18.82 151.07,19.8 151.66,20.38 151.66,20.54 151.94,20.82 U17.D2
  TOP w0.109: R317.1 C1027.1 149.69,17.33 150.35,17.99 150.67,17.99 151.07,18.39 151.07,18.82
EC_WP_OD: length 9.5
  TOP w0.079: v4(158.79,26.94) 158.29,26.94 158.01,26.66 156.85,26.66 U17.L10
  TOP w0.109: v4(158.79,26.94) 158.88,26.94 159.35,27.41 160.18,27.41 160.95,26.63 161.37,26.63 161.52,26.78 161.89,26.78 162.07,26.96 162.07,26.99 162.32,27.24 162.98,27.24 163.49,27.74 163.49,28.2 163.95,28.67 R52.2
ECH1_PACKET_MODE: length 25
  TOP w0.079: 169,20.78 168.85,20.64 v1(168.85,20.37) 168.56,20.37 168.09,20.84 167.25,20.84 U13.H5 ; U17.J6 v1(155.51,23.37)
  TOP w0.109: 169,20.78 169.06,20.84 169.97,20.84 170.35,21.22 R61.1 R357.2
  IN4 w0.079: 156.99,22.74 157.19,22.54 157.19,21.78 ; v1(155.51,23.37) 155.83,23.04 156.18,23.04 156.36,22.87 156.86,22.87
  IN4 w0.089: 156.99,22.74 156.86,22.87 ; 157.19,21.78 157.19,21.58 157.43,21.34 159.88,21.34 161.18,20.04 162.71,20.04 162.98,19.76 162.98,17.83 163.56,17.25 165.1,17.25 165.77,17.92 165.77,18.62 166.52,19.37 167.85,19.37 v1(168.85,20.37)
EDP_AUX_C_N: length 4
  TOP w0.097: C154.2 50.8,64.61 50.65,64.45 50.65,64.05 v2(50.82,63.88)
  BOTTOM w0.097: J23.20 51.25,62.27 51.09,62.42 51.09,62.63 50.89,62.83 50.67,62.83 50.34,63.16 50.34,63.4 v2(50.82,63.88)
EDP_AUX_C_P: length 3.9
  TOP w0.097: v2(50.18,63.88) 50.46,64.16 50.46,64.45 50.31,64.61 C153.2
  BOTTOM w0.097: J23.19 50.75,62.27 50.91,62.43 50.91,62.55 50.82,62.64 50.6,62.64 50.16,63.08 50.16,63.48 50.28,63.61 50.28,63.77 v2(50.18,63.88)
EDP_AUX_N: length 108.1
  TOP w0.089: v2(132.46,69.71) U1JSL.E10
  TOP w0.097: C154.1 50.8,65.06 50.7,65.16 50.7,65.31 50.86,65.47 51.19,65.47 51.58,65.86 51.58,67.75 v2(51.83,68.01)
  IN1 w0.097: v2(132.46,69.71) 132.46,69.84 132.58,69.95 132.9,69.95 133.51,70.56 133.51,72.6 128.77,77.34 122.63,77.34 120.91,79.06 120.59,79.06 120.51,79.15 120.51,79.5 120.13,79.87 119.73,79.87 119.51,79.65 119.51,79.17 119.4,79.06 119.11,79.06 119.02,79.15 119.02,81 118.74,81.28 118.29,81.28 118.01,81 118.01,79.15 117.91,79.06 117.5,79.06 117.4,79.15 117.4,80.11 117.21,80.3 116.58,80.3 116.39,80.11 116.39,79.15 116.3,79.06 112.93,79.06 111.65,80.34 101.07,80.34 100.65,79.92 96.28,79.92 96.11,79.75 88.9,79.75 86.56,77.42 77.58,77.42 75.53,75.36 74.51,75.36 73.75,74.6 73.75,73.86 69.14,69.25 67.08,69.25 66.62,68.79 53.21,68.79 52.95,68.54 52.95,67.85 52.72,67.63 51.72,67.63 51.63,67.71 51.63,67.8 v2(51.83,68.01)
  BOTTOM w0.097: v2(132.46,69.71) 132.46,69.83 132.56,69.93 133.12,69.93 133.34,69.71 R147.1
EDP_AUX_P: length 108.1
  TOP w0.089: U1JSL.F9 131.87,70.01 v2(132.02,70.16)
  TOP w0.097: C153.1 50.49,65.36 50.49,65.36 50.78,65.65 51.11,65.65 51.39,65.93 51.39,67.81 v2(51.2,68.01)
  IN1 w0.097: v2(51.2,68.01) 51.43,67.78 51.43,67.63 51.63,67.42 52.81,67.42 53.15,67.77 53.15,68.46 53.29,68.59 66.71,68.59 67.16,69.05 69.23,69.05 73.96,73.78 73.96,74.52 74.6,75.16 75.61,75.16 77.67,77.21 86.64,77.21 88.98,79.55 96.2,79.55 96.36,79.72 100.74,79.72 101.15,80.13 111.56,80.13 112.84,78.85 116.38,78.85 116.6,79.07 116.6,80.03 116.67,80.1 117.13,80.1 117.2,80.03 117.2,79.07 117.42,78.85 118,78.85 118.21,79.07 118.21,80.92 118.37,81.08 118.65,81.08 118.82,80.91 118.82,79.07 119.03,78.85 119.48,78.85 119.72,79.09 119.72,79.57 119.81,79.67 120.05,79.67 120.3,79.41 120.3,79.07 120.51,78.86 120.83,78.86 122.55,77.14 128.68,77.14 133.3,72.52 133.3,70.65 132.82,70.16 v2(132.02,70.16)
  BOTTOM w0.097: R146.1 133.2,70.12 132.06,70.12 v2(132.02,70.16)
EDP_HPD: length 74.4
  TOP w0.089: U1JSL.CM30 101.35,59.99 101.03,59.99 100.86,59.89 100.5,59.89 100.31,60.08 v2(99.97,60.08)
  IN1 w0.097: v2(99.97,60.08) 99.41,60.64 97.88,60.64 97.3,61.23 97.3,62.73 94.54,65.5 94.54,65.97 94.29,66.22 93.44,66.22 92.85,66.81 91.28,66.81 91.07,66.6 86.89,66.6 86.14,65.85 80,65.85 77.96,63.8 77.96,63.02 75.58,60.64 65.93,60.64 64.7,61.87 61.61,61.87 60.97,61.23 55.77,61.23 55.19,60.64 54.49,60.64 52.6,58.75 52.6,57.16 52.14,56.7 51.58,56.7 51.2,56.32 51.2,55.81 50.69,55.31 49.42,55.31 v2(47.52,57.21)
  BOTTOM w0.114: v2(47.52,57.21) 47.9,57.59 47.9,58.48 49.52,60.1 R200.1 51.07,60.39 51.28,60.59 52.14,60.59 52.25,60.7 J23.22
EDP_TX0_C_N: length 3.3
  TOP w0.097: v2(48.66,63.69) 48.85,63.88 48.85,64.04 C151.2
  BOTTOM w0.097: J23.16 49.25,62.3 49.39,62.44 49.39,62.6 48.89,63.11 48.89,63.46 v2(48.66,63.69)
EDP_TX0_C_P: length 3.3
  TOP w0.097: C152.2 49.03,64.09 49.03,63.95 v2(49.29,63.69)
  BOTTOM w0.097: v2(49.29,63.69) 49.07,63.47 49.07,63.18 49.57,62.68 49.57,62.42 49.75,62.24 J23.17
EDP_TX0_N: length 108.7
  TOP w0.089: v2(131.53,70.68) 131.46,70.75 U1JSL.G7
  TOP w0.097: v2(48.78,66.05) 48.78,66.05 49.01,65.82 49.01,65.65 48.8,65.44 48.8,65.07 C151.1
  IN1 w0.097: v2(48.78,66.05) 48.99,65.84 48.99,65.57 49.21,65.34 50.79,65.34 51.5,66.05 53.29,66.05 54.09,66.85 62.28,66.85 62.78,67.35 67.38,67.35 67.86,67.83 69.74,67.83 70.07,68.16 72.23,68.16 75.18,71.11 75.18,72.14 78.09,75.06 82.98,75.06 83.43,75.51 86.66,75.51 88.47,77.31 100.89,77.31 101.4,77.83 103.66,77.83 104.75,78.91 109.88,78.91 110.1,78.69 110.1,76.6 110.38,76.33 110.76,76.33 111.04,76.6 111.04,78.41 111.14,78.51 111.33,78.51 111.57,78.27 111.57,76.47 111.78,76.26 112.22,76.26 112.48,76.52 112.48,77.19 112.54,77.25 113.51,77.25 113.6,77.16 113.6,77.04 113.79,76.85 114.43,76.85 114.62,77.04 114.62,77.21 114.69,77.28 115.15,77.28 115.22,77.21 115.22,77.04 115.41,76.85 116.04,76.85 116.23,77.04 116.23,77.21 116.3,77.28 117.13,77.28 117.23,77.18 117.23,76.52 117.47,76.27 117.95,76.27 118.19,76.52 118.19,77.18 118.29,77.28 118.62,77.28 118.74,77.15 118.74,76.33 119.14,75.93 119.52,75.93 119.75,76.17 119.75,77.44 119.85,77.53 120.41,77.53 120.73,77.22 120.73,77.08 120.5,76.86 120.5,76.55 120.91,76.14 121.22,76.14 121.44,76.37 121.58,76.37 122.01,75.93 127.31,75.93 127.8,75.45 128.56,75.45 131.61,72.4 131.61,72.02 131.89,71.74 131.89,71.44 131.53,71.08 v2(131.53,70.68)
EDP_TX0_P: length 108.7
  TOP w0.089: U1JSL.F6 131.74,71.15 131.79,71.1 131.79,70.97 131.91,70.85 132.04,70.85 132.16,70.97 v2(132.16,71.13)
  TOP w0.097: v2(49.39,66.05) 49.19,65.85 49.19,65.57 48.99,65.37 48.99,65.09 49.28,64.8 C152.1
  IN1 w0.097: v2(132.16,71.13) 132.31,71.28 132.31,71.43 132.1,71.64 132.1,71.82 131.82,72.11 131.82,72.48 128.64,75.65 127.88,75.65 127.4,76.13 122.1,76.13 121.66,76.57 121.36,76.57 121.13,76.35 121,76.35 120.71,76.64 120.71,76.77 120.93,77 120.93,77.3 120.5,77.74 119.77,77.74 119.55,77.52 119.55,76.25 119.44,76.13 119.23,76.13 118.95,76.42 118.95,77.24 118.7,77.48 118.2,77.48 117.99,77.27 117.99,76.6 117.87,76.48 117.55,76.48 117.43,76.6 117.43,77.27 117.21,77.48 116.22,77.48 116.03,77.29 116.03,77.12 115.96,77.05 115.49,77.05 115.42,77.12 115.42,77.29 115.23,77.48 114.6,77.48 114.41,77.29 114.41,77.12 114.34,77.05 113.88,77.05 113.81,77.12 113.81,77.24 113.59,77.46 112.46,77.46 112.27,77.27 112.27,76.6 112.13,76.46 111.87,76.46 111.77,76.56 111.77,78.36 111.42,78.71 111.05,78.71 110.84,78.5 110.84,76.69 110.68,76.53 110.47,76.53 110.3,76.69 110.3,78.78 109.96,79.12 104.66,79.12 103.57,78.03 101.32,78.03 100.8,77.51 88.38,77.51 86.58,75.71 83.35,75.71 82.9,75.26 78.01,75.26 74.97,72.23 74.97,71.19 72.15,68.36 69.99,68.36 69.66,68.03 67.78,68.03 67.3,67.55 62.7,67.55 62.2,67.05 54.01,67.05 53.21,66.25 51.41,66.25 50.7,65.54 49.3,65.54 49.19,65.65 49.19,65.85 v2(49.39,66.05)
EDP_TX1_C_N: length 1.7
  BOTTOM w0.097: J23.3 42.75,60.9 42.91,60.75 42.91,60.41 C149.2
EDP_TX1_C_P: length 1.7
  BOTTOM w0.097: J23.4 43.25,60.89 43.09,60.73 43.09,60.37 C150.2
EDP_TX1_N: length 112.7
  TOP w0.089: v1(132.21,72.24) 132.21,72.07 132.4,71.88 132.54,71.88 132.64,71.98 U1JSL.D4
  IN1 w0.097: v2(40.4,61.28) 40.56,61.28 40.8,61.52 40.8,61.89 40.87,61.96 43.73,61.96 47.11,65.34 47.35,65.34 47.81,65.8 47.81,66.24 48.25,66.69 53.05,66.69 53.83,67.46 61.9,67.46 62.41,67.97 67.01,67.97 67.48,68.44 69.48,68.44 70.95,69.9 72.07,69.9 77.84,75.68 82.75,75.68 83.2,76.12 86.42,76.12 88.22,77.93 100.66,77.93 101.26,78.53 103.38,78.53 104.36,79.51 111.22,79.51 112.48,78.25 120.55,78.25 122.26,76.54 128.43,76.54 132.67,72.3 132.67,72.01 132.61,71.95 132.5,71.95 v1(132.21,72.24)
  BOTTOM w0.097: C149.1 42.91,59.65 42.98,59.58 42.98,59.43 42.06,58.51 40.18,58.51 39.9,58.79 39.9,61.58 39.97,61.66 40.06,61.66 40.4,61.31 v2(40.4,61.28)
EDP_TX1_P: length 112.7
  TOP w0.089: U1JSL.E5 132.72,71.63 v1(132.74,71.61)
  IN1 w0.097: v2(40.4,61.89) 40.51,61.89 40.79,62.16 43.65,62.16 47.03,65.55 47.27,65.55 47.6,65.88 47.6,66.32 48.17,66.89 52.97,66.89 53.74,67.66 61.82,67.66 62.33,68.17 66.93,68.17 67.4,68.64 69.4,68.64 70.86,70.11 71.98,70.11 77.76,75.88 82.67,75.88 83.11,76.33 86.33,76.33 88.14,78.13 100.57,78.13 101.17,78.73 103.29,78.73 104.28,79.72 111.3,79.72 112.56,78.46 120.63,78.46 122.34,76.74 128.52,76.74 132.87,72.39 132.87,71.74 v1(132.74,71.61)
  BOTTOM w0.097: C150.1 43.17,59.46 43.17,59.35 42.14,58.32 40.1,58.32 39.71,58.71 39.71,61.66 39.89,61.84 40.36,61.84 v2(40.4,61.89)
EDP_TX2_C_N: length 0.9
  TOP w0.097: C273.2 39.16,63.34 39.3,63.49 39.3,63.72 39.11,63.91 R372.1
EDP_TX2_C_P: length 0.9
  TOP w0.097: C264.2 39.63,63.34 39.48,63.49 39.48,63.7 39.67,63.89 R373.1
EDP_TX2_N: length 110.9
  TOP w0.089: U1JSL.J5 130.34,71.48 v1(130.53,71.67)
  TOP w0.097: C273.1 39.32,62.89 39.38,62.83 39.38,62.63 39.23,62.47 39.06,62.47 38.69,62.11 38.69,61.26 v2(39.29,60.67)
  IN1 w0.097: v1(130.53,71.67) 130.53,72.62 130.36,72.79 130.1,72.79 129.89,73 129.89,73.26 129.69,73.47 129.55,73.47 129.45,73.37 129.15,73.37 128.74,73.78 128.74,74.09 128.83,74.18 128.83,74.32 128.35,74.8 127.44,74.8 126.92,75.32 118.78,75.32 118.45,75.65 116.28,75.65 115.68,76.25 114.22,76.25 113.61,75.64 110.01,75.64 109.49,76.16 109.49,78.16 109.34,78.31 109.05,78.31 108.88,78.15 108.88,77.49 108.56,77.18 108.2,77.18 107.9,77.47 107.9,78.13 107.72,78.31 105.64,78.31 104.51,77.18 101.62,77.18 101.13,76.69 88.71,76.69 86.91,74.89 83.68,74.89 83.23,74.44 78.33,74.44 75.79,71.9 75.79,70.84 72.49,67.55 70.33,67.55 70,67.22 68.24,67.22 67.62,66.6 65.89,66.6 65.54,66.24 54.34,66.24 53.49,65.39 51.69,65.39 51.03,64.73 48.87,64.73 47.71,63.56 47.71,62.99 47.22,62.51 45.99,62.51 44.81,61.33 41.88,61.33 41.19,60.64 40.15,60.64 39.75,61.05 39.64,61.05 39.29,60.69 v2(39.29,60.67)
