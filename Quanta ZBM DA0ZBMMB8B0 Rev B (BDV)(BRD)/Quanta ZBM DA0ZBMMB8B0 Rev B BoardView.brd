# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TX2_P: length 110.9
  TOP w0.089: U1JSL.H6 v1(131.12,71.23)
  TOP w0.097: v2(39.29,61.25) 38.96,61.25 38.88,61.33 38.88,62.03 39.14,62.29 39.31,62.29 39.59,62.57 39.59,62.72 C264.1
  IN1 w0.097: v2(39.29,61.25) 39.83,61.25 40.24,60.84 41.11,60.84 41.79,61.53 44.72,61.53 45.9,62.71 47.14,62.71 47.5,63.07 47.5,63.65 48.79,64.93 50.95,64.93 51.61,65.59 53.4,65.59 54.25,66.44 65.45,66.44 65.81,66.8 67.54,66.8 68.16,67.42 69.92,67.42 70.25,67.75 72.41,67.75 75.58,70.93 75.58,71.98 78.24,74.64 83.15,74.64 83.59,75.09 86.82,75.09 88.63,76.89 101.05,76.89 101.54,77.38 104.42,77.38 105.56,78.52 107.8,78.52 108.11,78.21 108.11,77.55 108.28,77.38 108.48,77.38 108.68,77.58 108.68,78.23 108.96,78.52 109.42,78.52 109.7,78.24 109.7,76.24 110.1,75.84 113.52,75.84 114.13,76.45 115.77,76.45 116.36,75.86 118.53,75.86 118.86,75.53 127,75.53 127.52,75 128.44,75 129.04,74.4 129.04,74.1 128.94,74 128.94,73.86 129.23,73.57 129.37,73.57 129.47,73.67 129.77,73.67 130.09,73.35 130.09,73.08 130.18,72.99 130.45,72.99 130.73,72.71 130.73,71.99 130.9,71.82 130.9,71.44 v1(131.12,71.23)
EDP_TX3_C_N: length 1.2
  TOP w0.097: R370.1 37.27,64.01 37.27,63.5 37.11,63.34 C275.2
EDP_TX3_C_P: length 1.2
  TOP w0.097: R371.1 37.45,63.97 37.45,63.5 37.61,63.34 C274.2
EDP_TX3_N: length 111.8
  TOP w0.089: v1(129.69,71.16) 129.8,71.27 129.95,71.27 130.16,71.06 130.16,70.91 U1JSL.J7
  TOP w0.097: v2(37.99,61.28) 37.99,61.34 37.72,61.61 37.58,61.61 37.37,61.82 37.37,62.8 37.28,62.89 C275.1
  IN1 w0.097: v1(129.69,71.16) 129.75,71.16 129.85,71.26 129.85,71.78 129.64,71.99 129.64,72.39 129.44,72.59 129.04,72.59 127.89,73.74 127.64,73.74 126.66,74.71 118.51,74.71 118.23,74.99 110.1,74.99 109.49,74.38 108.79,74.38 108.48,74.7 108.48,75.94 108.29,76.12 107.99,76.12 107.8,75.94 107.8,75.17 107.57,74.94 106.81,74.94 106.47,75.28 106.47,76.99 106.18,77.28 105.6,77.28 104.89,76.57 101.86,76.57 101.37,76.07 88.96,76.07 87.15,74.26 83.9,74.26 83.47,73.82 78.58,73.82 76.4,71.64 76.4,70.45 73.88,67.93 73.88,67.5 73.33,66.95 73.07,66.95 72.1,65.97 66.12,65.97 65.77,65.62 54.58,65.62 53.71,64.76 51.92,64.76 51.45,64.29 51.45,63.07 50.7,62.32 48.55,62.32 48.02,61.78 46.12,61.78 45.05,60.72 42.13,60.72 41.45,60.03 38.95,60.03 38.44,60.54 38.44,61.4 38.34,61.49 38.21,61.49 v2(37.99,61.28)
EDP_TX3_P: length 111.8
  TOP w0.089: U1JSL.J8 v2(129.68,70.54)
  TOP w0.097: v2(37.99,61.91) 37.88,61.8 37.66,61.8 37.55,61.9 37.55,62.71 C274.1
  IN1 w0.097: v2(129.68,70.54) 130.05,70.92 130.05,71.87 129.84,72.08 129.84,72.47 129.52,72.79 129.12,72.79 127.98,73.94 127.72,73.94 126.75,74.92 118.6,74.92 118.32,75.2 110.02,75.2 109.41,74.59 108.88,74.59 108.68,74.78 108.68,76.02 108.37,76.33 107.9,76.33 107.6,76.02 107.6,75.25 107.49,75.14 106.9,75.14 106.67,75.37 106.67,77.07 106.26,77.48 105.51,77.48 104.81,76.78 101.78,76.78 101.28,76.28 88.87,76.28 87.06,74.46 83.82,74.46 83.38,74.03 78.5,74.03 76.19,71.72 76.19,70.53 73.68,68.02 73.68,67.58 73.24,67.15 72.98,67.15 72.01,66.18 66.04,66.18 65.68,65.82 54.49,65.82 53.63,64.96 51.83,64.96 51.25,64.37 51.25,63.16 50.61,62.52 48.47,62.52 47.94,61.99 46.03,61.99 44.97,60.92 42.05,60.92 41.36,60.23 39.03,60.23 38.64,60.62 38.64,61.48 38.43,61.7 38.21,61.7 v2(37.99,61.91)
EMMC_CLK: length 42.6
  TOP w0.089: v2(104.57,55.27) 104.73,55.43 U1JSL.CF40
  TOP w0.109: R164.2 R174.1 74.78,47.81 75.08,47.51 75.23,47.51 75.34,47.62 75.34,48.01 75.52,48.2 75.72,48.2 75.83,48.09 75.83,47.54 75.92,47.45 76.23,47.45 76.32,47.54 76.32,48.09 76.43,48.19 76.64,48.19 76.81,48.03 76.81,47.54 76.92,47.43 v2(77.36,47.43)
  IN1 w0.097: v2(77.36,47.43) 78.66,48.73 78.66,52.2 83.26,56.81 86.07,56.81 86.41,56.46 87.2,56.46 87.85,55.82 92.28,55.82 93.48,57.02 94.42,57.02 94.52,56.92 94.52,56.67 94.61,56.58 94.9,56.58 94.99,56.67 94.99,56.92 95.09,57.02 95.46,57.02 96.13,56.35 98.22,56.35 98.57,56.7 100.11,56.7 100.36,56.45 102.13,56.45 102.62,55.96 103.3,55.96 103.52,55.74 104.11,55.74 v2(104.57,55.27)
EMMC_CLK_R: length 8.7
  TOP w0.109: 66.96,47.85 U14.M6
  TOP w0.117: 66.96,47.85 66.96,47.78 v2(67.3,47.44) ; v2(70.63,46.8) 70.76,46.92 70.76,47.69 70.93,47.86 72.33,47.86 v4(72.54,48.07) 73.04,48.07 73.23,48.26 R164.1
  IN4 w0.102: v2(70.63,46.8) 70.25,47.18 69.74,47.18 68.85,48.07 67.93,48.07 v2(67.3,47.44)
EMMC_CMD: length 48.9
  TOP w0.089: U1JSL.CJ46 v2(103.77,53.23)
  TOP w0.109: R165.2 R178.2 v4(75.58,48.95) 76.58,48.95 78,47.53 78,43.93 76.63,42.57 76.63,39.74 76.23,39.34 v2(76.23,38.72)
  IN1 w0.097: v2(76.23,38.72) 76.78,38.72 80.56,42.51 81.45,42.51 91.13,52.19 100.29,52.19 100.53,51.95 101.47,51.95 101.89,52.38 102.07,52.38 102.92,53.23 v2(103.77,53.23)
EMMC_CMD_R: length 8
  TOP w0.109: 67.55,47.85 67.46,47.94 U14.M5
  TOP w0.117: v2(67.97,47.43) 67.55,47.85 ; v2(70,46.8) 70.43,47.23 70.43,47.86 70.76,48.19 71.77,48.19 72.98,49.4 R165.1
  IN4 w0.102: v2(70,46.8) 69.61,46.8 68.98,47.43 v2(67.97,47.43)
EMMC_D0: length 47.2
  TOP w0.089: U1JSL.CJ41 103.36,55.18 103.36,54.75 v2(103.36,54.75)
  TOP w0.109: v2(74.28,43.07) 74.59,42.77 74.59,42.77 R167.2 74.67,42.19 74.2,42.19 73.72,42.67 R156.2
  IN1 w0.097: v2(103.36,54.75) 103.01,54.75 102.53,55.23 102.2,55.23 101.97,55 100.41,55 100.07,55.34 97.19,55.34 96.99,55.14 96.25,55.14 95.74,54.64 87.32,54.64 86.69,55.27 83.39,55.27 81.62,53.5 81.62,53.31 82.17,52.76 82.17,52.63 82.02,52.48 81.89,52.48 81.34,53.03 81.2,53.03 81.05,52.88 81.05,52.75 81.6,52.19 81.6,52.06 81.46,51.91 81.32,51.91 80.91,52.32 80.6,52.32 80.03,51.75 80.03,50.85 80.18,50.7 80.96,50.7 81.04,50.61 81.04,50.42 80.94,50.32 80.12,50.32 80.03,50.23 80.03,50.04 80.13,49.93 80.96,49.93 81.04,49.85 81.04,49.66 80.94,49.55 80.14,49.55 80.03,49.44 80.03,48.36 76.59,44.92 75.93,44.92 74.28,43.28 v2(74.28,43.07)
EMMC_D0_R: length 5.3
  TOP w0.109: U14.A3 68.82,42.08 70.34,42.08 71.09,42.83 v4(72.48,42.83) R156.1
EMMC_D1: length 45
  TOP w0.089: U1JSL.CJ45 v2(103.78,53.89)
  TOP w0.109: v2(75.54,40.98) 75.54,40.44 75.12,40.01 74.61,40.01 74.36,40.26 R168.2 R157.2
  IN1 w0.097: v2(103.78,53.89) 103.47,53.58 102.69,53.58 102.34,53.24 101.88,53.24 101.62,52.99 100.31,52.99 99.84,52.51 97,52.51 96.97,52.54 90.99,52.54 84.82,46.37 84.69,46.37 84.37,46.69 84.23,46.69 84.12,46.58 84.12,46.44 84.44,46.13 84.44,45.99 84.33,45.88 84.19,45.88 83.88,46.2 83.74,46.2 83.63,46.08 83.63,45.95 83.94,45.63 83.94,45.49 83.83,45.38 83.7,45.38 83.38,45.7 83.24,45.7 83.13,45.59 83.13,45.45 83.45,45.14 83.45,45 83.34,44.89 83.2,44.89 82.88,45.2 82.75,45.2 82.64,45.09 82.64,44.96 82.95,44.64 82.95,44.5 82.84,44.39 82.7,44.39 82.39,44.71 82.25,44.71 82.14,44.6 82.14,44.46 82.46,44.14 82.46,44.01 82.35,43.9 82.21,43.9 81.89,44.21 81.76,44.21 81.64,44.1 81.64,43.96 81.96,43.65 81.96,43.51 81.85,43.4 81.71,43.4 81.4,43.72 81.26,43.72 81.15,43.61 81.15,43.47 81.46,43.15 81.46,43.02 81.35,42.9 81.22,42.9 80.9,43.22 80.76,43.22 77.99,40.45 76.08,40.45 v2(75.54,40.98)
EMMC_D1_R: length 6.9
  TOP w0.081: 67.97,42.15 67.97,42.43 U14.A4
  TOP w0.109: 67.97,42.15 67.97,41.9 69.46,40.41 72.02,40.41 v4(72.51,40.91) 73,40.41 R157.1
EMMC_D2: length 45.2
  TOP w0.089: U1JSL.CJ40 103.15,55.62 v1(102.89,55.36)
  TOP w0.109: v2(75.04,38.71) 75.04,37.81 74.66,37.43 R170.2 R158.2
  IN1 w0.097: v1(102.89,55.36) 102.68,55.58 102.24,55.58 101.93,55.26 100.77,55.26 100.41,55.63 95.73,55.63 95.7,55.65 94.21,55.65 93.55,54.99 87.49,54.99 86.85,55.62 83.25,55.62 79.62,51.99 79.62,48.48 76.41,45.27 75.76,45.27 73.86,43.37 73.86,40.44 75.04,39.26 v2(75.04,38.71)
EMMC_D2_R: length 8.9
  TOP w0.109: R158.1 73.68,37.99 72.57,39.1 72.46,39.1 71.93,39.62 69.22,39.62 67.31,41.54 67.31,42.29 U14.A5
EMMC_D3: length 46.1
  TOP w0.089: U1JSL.CK45 v2(102.23,53.69)
  TOP w0.109: v2(76.14,42.07) 76.14,42.62 77.49,43.97 v4(77.49,45.12) 77.37,45.24 77.08,45.24 76.97,45.13 76.97,44.78 76.86,44.67 76.67,44.67 76.56,44.78 76.56,45.13 76.45,45.24 76.25,45.24 76.14,45.13 76.14,44.73 76.03,44.62 75.84,44.62 75.73,44.73 75.73,45.13 75.62,45.24 75.4,45.24 75.27,45.11 R171.2 R159.2
  IN1 w0.097: v2(76.14,42.07) 76.14,42.55 76.45,42.86 78.15,42.86 78.4,43.11 78.53,43.11 78.92,42.72 79.06,42.72 79.17,42.83 79.17,42.97 78.78,43.36 78.78,43.49 78.89,43.61 79.03,43.61 79.42,43.21 79.56,43.21 79.67,43.33 79.67,43.46 79.28,43.85 79.28,43.99 79.39,44.1 79.53,44.1 79.92,43.71 80.05,43.71 80.16,43.82 80.16,43.96 79.77,44.35 79.77,44.49 79.88,44.6 80.02,44.6 80.41,44.21 80.55,44.21 80.66,44.32 80.66,44.45 80.27,44.84 80.27,44.98 82.85,47.56 85.02,47.56 90.7,53.24 96.55,53.24 96.96,53.65 101.19,53.65 101.31,53.77 102.15,53.77 v2(102.23,53.69)
EMMC_D3_R: length 6.1
  TOP w0.081: 70.05,43.2 70.04,43.19 69.21,43.19 U14.B2
  TOP w0.109: R159.1 72.59,44 v4(72.48,44.11) 72.11,43.73 70.58,43.73 70.05,43.2
EMMC_D4: length 47.6
  TOP w0.089: U1JSL.CM43 102.33,54.7 v2(102.43,54.81)
  TOP w0.109: v2(76.43,44.15) 76.66,43.92 76.66,43.67 76.36,43.37 75.89,43.37 75.62,43.64 75.06,43.64 74.92,43.5 R172.2 74.77,43.21 74.38,43.59 R160.2
  IN1 w0.097: v2(76.43,44.15) 81.43,49.14 81.43,49.85 81.51,49.93 82.47,49.93 82.57,50.04 82.57,50.23 82.48,50.32 81.51,50.32 81.43,50.4 81.43,50.61 81.51,50.7 82.47,50.7 82.57,50.8 82.57,50.99 82.48,51.08 80.47,51.08 80.4,51.15 80.4,51.36 80.48,51.44 82.55,51.44 82.7,51.59 82.7,53.11 82.6,53.21 82.28,53.21 82.19,53.31 82.19,53.51 82.28,53.61 82.6,53.61 82.7,53.71 82.7,54.08 83.54,54.92 86.54,54.92 87.93,53.53 88.29,53.53 88.39,53.43 88.39,52.86 88.48,52.77 88.69,52.77 88.79,52.86 88.79,53.43 88.89,53.53 89.49,53.53 90.25,54.29 95.89,54.29 96.36,54.76 97.12,54.76 97.49,55.14 100.01,55.14 100.34,54.81 v2(102.43,54.81)
EMMC_D4_R: length 5.3
  TOP w0.081: U14.B3 68.71,42.69 69.72,42.69
  TOP w0.109: R160.1 73.05,43.37 70.73,43.37 70.05,42.69 69.72,42.69
EMMC_D5: length 44.1
  TOP w0.089: U1JSL.CL44 v2(101.69,54.34)
  TOP w0.109: v2(74.26,41.69) 74.26,41.68 R173.2 74.92,41.55 74.55,41.18 v4(73.88,41.18) 72.89,41.18 72.66,41.41 71.62,41.41 71.52,41.52 71.52,41.79 71.7,41.97 72.79,41.97 73.09,41.67 73.42,41.67 73.72,41.96 R161.2
  IN1 w0.097: v2(74.26,41.69) 74.26,41.72 74.55,42.01 74.55,42.21 76.01,43.67 76.58,43.67 77.25,44.34 77.39,44.34 77.92,43.81 78.05,43.81 78.17,43.92 78.17,44.06 77.64,44.59 77.64,44.72 77.75,44.83 77.88,44.83 78.41,44.3 78.55,44.3 78.66,44.42 78.66,44.55 78.13,45.08 78.13,45.22 82.35,49.43 85.89,49.43 90.39,53.94 96.12,53.94 96.54,54.36 101.67,54.36 v2(101.69,54.34)
EMMC_D5_R: length 7.6
  TOP w0.081: U14.B4 68.21,42.69 68.21,42.43 68.21,42.43 68.21,42.34 68.33,42.21 68.33,42.15
  TOP w0.109: R161.1 73.27,42.15 73.04,42.38 71.59,42.38 70.67,41.46 70.67,41.01 70.52,40.86 69.53,40.86 68.33,42.05 68.33,42.15
EMMC_D6: length 44.7
  TOP w0.089: U1JSL.CM46 v2(101.52,53.4)
  TOP w0.109: v2(76.14,40.98) 76.14,40.33 v4(75.69,39.88) 75.29,39.49 74.55,39.49 74.29,39.75 R175.2 R162.2
  IN1 w0.097: v2(101.52,53.4) 101.41,53.3 98.48,53.3 97.99,52.81 97.08,52.81 97,52.89 90.84,52.89 85.13,47.18 84.19,47.18 83.68,46.67 83.54,46.67 83.15,47.06 83.02,47.06 82.9,46.94 82.9,46.81 83.3,46.42 83.3,46.28 83.18,46.17 83.05,46.17 82.66,46.56 82.52,46.56 82.41,46.45 82.41,46.31 82.8,45.92 82.8,45.79 82.69,45.67 82.55,45.67 82.16,46.06 82.02,46.06 81.91,45.95 81.91,45.82 82.3,45.43 82.3,45.29 82.19,45.18 82.06,45.18 81.67,45.57 81.53,45.57 81.42,45.46 81.42,45.32 81.81,44.93 81.81,44.79 81.7,44.68 81.56,44.68 81.17,45.07 81.03,45.07 80.92,44.96 80.92,44.82 81.31,44.43 81.31,44.3 79.33,42.31 77.77,42.31 77.49,42.04 77.49,41.08 77.4,40.98 77.24,40.98 77.14,41.08 77.14,42.41 77.05,42.51 76.89,42.51 76.79,42.41 76.79,41.08 76.69,40.98 v2(76.14,40.98)
EMMC_D6_R: length 8.1
  TOP w0.081: U14.B5 67.46,42.88 67.71,42.63 67.71,42.34 67.61,42.24 67.61,42.15
  TOP w0.109: R162.1 73.06,39.3 72.74,39.62 v4(72.6,39.62) 72.18,40.04 69.32,40.04 67.61,41.75 67.61,42.15
EMMC_D7: length 43.6
  TOP w0.089: U1JSL.CH42 v2(104.16,54.38)
  TOP w0.109: R163.2 R177.2 73.3,37.04 74.9,37.04 75.64,37.78 v2(75.64,38.71)
  IN1 w0.097: v2(75.64,38.71) 75.64,39.3 74.55,40.39 74.55,41.18 75.24,41.87 75.24,42.21 76.36,43.32 78.07,43.32 82.7,47.94 84.9,47.94 90.55,53.59 96.29,53.59 96.7,53.99 96.86,53.99 96.88,54.01 101.43,54.01 101.47,53.97 101.91,53.97 102.32,54.38 104.12,54.38 v2(104.16,54.38)
EMMC_D7_R: length 9
  TOP w0.081: 66.71,42.17 66.71,42.69 U14.B6
  TOP w0.109: R163.1 72.01,37.88 71.19,38.7 v4(70.35,38.7) 69.91,39.13 68.64,39.13 66.41,41.36 66.41,41.87 66.71,42.17
EMMC_RCLK: length 44.6
  TOP w0.089: U1JSL.CE38 105.1,56.66 104.83,56.33 v1(104.81,56.33)
  TOP w0.109: v2(74.58,45.14) 74.57,45.15 74.57,45.95 74.29,46.23 R176.1 73.49,46.23 73.37,46.11 R166.2
  IN1 w0.097: v2(74.58,45.14) 74.55,45.17 74.55,45.4 74.03,45.92 74.03,46.16 74.24,46.37 74.4,46.37 74.64,46.12 74.78,46.12 74.98,46.32 74.98,46.46 74.67,46.77 74.67,46.91 74.88,47.11 75.01,47.11 75.32,46.8 75.46,46.8 75.66,47 75.66,47.14 75.38,47.42 75.38,47.61 75.53,47.77 75.7,47.77 75.89,47.58 76.03,47.58 78.14,49.68 78.14,52.36 83.08,57.3 86.26,57.3 86.6,56.96 87.4,56.96 87.55,56.81 92.6,56.81 93.23,57.45 95.54,57.45 96.23,56.75 98.16,56.75 98.37,56.96 100.35,56.96 100.6,56.7 104.43,56.7 v1(104.81,56.33)
EMMC_RCLK_R: length 7.4
  TOP w0.109: 73.06,45.14 72.87,45.34 72.87,45.83 72.69,46.01 72.05,46.01 71.78,45.73 ; U14.H5 67.68,46.16 v2(67.96,46.16)
  TOP w0.117: 73.06,45.14 R166.1 ; 71.78,45.73 71.57,45.53 70.38,45.53 v2(70.07,45.21)
  IN4 w0.102: v2(70.07,45.21) 69.2,46.08 68.04,46.08 v2(67.96,46.16)
EMMC_RCOMP: length 6.6
  TOP w0.089: U1JSL.CN50 101,50.84 101,50.5 100.81,50.31 100.46,50.31 ; v4(96.45,52.28) 96.73,52.01 96.74,52.01 97.09,51.65 R3812.1
  TOP w0.18: 100.46,50.31 98.39,50.31 97.51,51.19 R3812.1
EMMC_RST_L: length 46.4
  TOP w0.089: U1JSL.CH40 103.8,55.45 v2(103.96,55.29)
  TOP w0.109: v2(75.24,45.82) 75.44,45.62 77.5,45.62 77.62,45.74 77.62,46.14 77.5,46.25 v4(76.65,46.25) 76.54,46.36 76.54,46.85 76.43,46.96 76.23,46.96 76.12,46.85 76.12,46.15 76.01,46.04 75.81,46.04 75.71,46.15 75.71,46.88 75.6,46.99 75.4,46.99 75.29,46.88 75.29,46.41 75.18,46.3 74.99,46.3 74.88,46.41 74.88,47 74.64,47.24 R169.2
  IN1 w0.097: v2(75.24,45.82) 76.43,45.82 79.27,48.65 79.27,52.14 83.1,55.97 87,55.97 87.63,55.34 92.5,55.34 93.23,56.07 95.79,56.07 95.94,55.92 101.34,55.92 101.49,56.07 102.2,56.07 102.51,55.77 103.19,55.77 103.67,55.29 v2(103.96,55.29)
EMMC_RST_L_R: length 7.5
  TOP w0.109: v2(70,46.04) 71.16,46.04 71.92,46.79 v4(72.61,46.79) R80.2
  TOP w0.117: v2(67.96,46.76) 67.64,46.76 U14.K5 ; R80.2 R169.1
  IN4 w0.102: v2(67.96,46.76) 69.27,46.76 v2(70,46.04)
EMMC_VDDI_BYP: length 5.6
  TOP w0.081: 69.74,43.69 69.21,43.69 U14.C2
  TOP w0.254: 69.74,43.69 70.36,44.31 71.34,44.31 v4(72.43,45.4) 72.43,45.18 73.14,44.48 C63.1
EMR_INT_ODL: length 2.4
  TOP w0.089: v2(99.08,64.96) 99.13,64.96 99.31,65.13 100.67,65.13 U1JSL.CR19
  BOTTOM w0.114: TP120.1 99.39,65.21 99.13,64.96 v2(99.08,64.96)
EMR_RESET_L: length 1.7
  TOP w0.089: v1(103.33,70.43) 103.77,70 U1JSL.CH9
  BOTTOM w0.089: TP121.1 103.33,70.74 v1(103.33,70.43)
EN_BL_OD: length 146.6
  TOP w0.079: v1(152.26,25.97) U17.E9
  IN2 w0.079: 150.26,25.08 150.39,25.21 150.39,25.46 150.57,25.64 151.94,25.64 v1(152.26,25.97)
  IN2 w0.097: 150.26,25.08 148.94,23.76 147.76,23.76 147.35,24.17 145.85,24.17 145.38,24.64 142.63,24.64 140.99,23 138.39,23 136.46,21.07 136.46,20.47 135.67,19.69 131.51,19.69 131.11,19.29 124.87,19.29 124.38,19.78 117.19,19.78 115.9,21.07 107.93,21.07 107.23,20.37 105.42,20.37 104.38,19.34 93.16,19.34 90.92,21.57 87.05,21.57 85.86,22.75 v2(85.54,22.75) ; v2(45.87,54.04) 45.87,51.34 51.67,45.54 51.67,39.6 54.94,36.32 57.27,36.32 58.31,35.29 60.43,35.29 71.48,24.24 71.84,24.24 73.03,23.05 77.13,23.05 77.82,23.74 80.37,23.74 v2(80.57,23.55)
  BOTTOM w0.114: v2(80.57,23.55) 80.76,23.35 84.95,23.35 v2(85.54,22.75) ; J23.23 52.75,60.25 D23.2 52.22,58.99 52.47,58.74 R201.2 53.51,57.88 52.34,56.7 48.53,56.7 v2(45.87,54.04)
EN_KB_BL: length 171.7
  TOP w0.079: v1(153.56,23.37) U17.G5
  TOP w0.109: U5.C1 77.28,11.71 77.67,12.1 v2(77.67,12.32) 77.81,12.46 77.81,14.03 77.91,14.13 R91352.1
  IN1 w0.097: v2(94.86,16.41) 91.6,13.16 88.17,13.16 87.06,12.05 85.62,12.05 84.75,12.91 78.26,12.91 v2(77.67,12.32)
  IN2 w0.097: v2(94.86,16.41) 96.05,17.6 101.89,17.6 102.93,18.64 104.7,18.64 104.96,18.89 110.81,18.89 111.01,18.7 116.45,18.7 118.93,16.22 119.03,16.22 v2(119.23,16.02)
  IN4 w0.079: 152.34,21.78 152.79,22.22 153.09,22.22 153.24,22.37 153.24,23.04 v1(153.56,23.37)
  IN4 w0.089: v2(119.23,16.02) 119.42,15.82 145.51,15.82 148.98,19.29 151.02,19.29 151.8,20.06 151.8,21.23 152.34,21.78 ; v1(153.56,23.37) 154.21,23.37 154.55,23.7 156.52,23.7 157.29,22.92 158.58,22.92 161.27,20.23 162.95,20.23 163.19,19.99 163.19,17.9 163.64,17.44 165.02,17.44 165.58,18 165.58,18.78 166.5,19.7 166.75,19.7 168.17,21.12 171.84,21.12 173.67,19.3 180.28,19.3 182.45,21.47 182.45,24.6 183.96,26.11 184.97,26.11 188.22,29.36 188.22,35.06 186.68,36.6 186.68,42.28 186.29,42.67 186.29,45.64 186.89,46.23 186.89,47.52 v2(187.58,48.22)
  BOTTOM w0.114: v2(187.58,48.22) 187.74,48.38 193.53,48.38 195.61,50.47 195.73,50.58 195.73,54.44 194.51,55.65 J12.10
EN_PP1200_CAMERA: length 5.2
  TOP w0.089: U1JSL.CL17 101.66,66.1 101.23,66.1 101.16,66.13 100.96,66.13 100.78,66.02 100.5,66.02 100.49,66.02 100.39,66.1 100.29,66.17 99.84,66.17 99.55,66.46 99.1,66.46 v2(98.75,66.1)
  BOTTOM w0.114: TP129.1 99.26,66.62 v2(98.75,66.1)
EN_PP2800_CAMERA: length 5.8
  TOP w0.089: U1JSL.CN19 101.07,65.3 100.77,65.44 100.6,65.44 100.46,65.31 99.5,65.31 99.43,65.37 98.32,65.37 97.92,64.97 v2(97.89,64.97)
  BOTTOM w0.114: v2(97.89,64.97) 97.87,64.97 96.72,66.12 TP128.1
EN_PP3300_A: length 142
  TOP w0.079: v1(151.61,25.97) U17.D9
  TOP w0.109: v2(37.3,49.52) 37.41,49.63 U23.3
  IN2 w0.097: v1(151.61,25.97) 151.23,26.35 150.69,26.35 150.01,25.67 150.01,25.08 148.94,24.02 147.84,24.02 147.48,24.38 145.93,24.38 145.48,24.84 141.54,24.84 140.96,24.26 139.06,24.26 136.86,22.06 134.88,22.06 134.19,21.37 134.19,20.48 133.79,20.08 131.31,20.08 130.91,19.69 125.07,19.69 124.57,20.18 117.44,20.18 116.15,21.47 107.74,21.47 107.13,20.86 105.26,20.86 104.17,19.78 102.73,19.78 101.8,20.71 92.35,20.71 91.1,21.96 89.01,21.96 86.81,24.17 83.49,24.17 81.16,21.84 72.1,21.84 63.92,30.01 63.92,30.31 60.61,33.63 53.18,33.63 50.45,36.36 50.45,45.13 49.45,46.12 41.61,46.12 38.82,48.91 37.91,48.91 v2(37.3,49.52)
  BOTTOM w0.114: v2(37.3,49.52) 37.55,49.78 R474.1
EN_PP3300_G: length 1.9
  TOP w0.109: R464.1 42.02,45.22 R301.1 R300.2 C290.1
EN_PP3300_G_L: length 83.7
  TOP w0.109: 87.05,14.91 87.02,14.88 86.62,14.88 85.97,15.53 R296.2 84.94,15.89 83.25,15.89 D30.2 82.52,15.16 82.52,12.84 82.4,12.72 D29.2 ; 87.05,14.91 87.07,14.89 Q18.2 87.59,14.3 87.6,14.31 C243.1 ; 87.05,14.91 Q16.1 ; Q17.3 88.08,13.5 88.22,13.65 C243.1 ; Q23.2 153.63,15.79 153.21,16.22 v1(153.21,16.32) ; C243.1 88.79,14.31 89.01,14.53 v2(89.01,15.53)
  IN2 w0.097: v1(153.21,16.32) 149.47,12.58 113.8,12.58 109.78,16.6 108.18,16.6 107.33,15.75 104.95,15.75 103.34,14.14 93.43,14.14 92.44,15.13 89.41,15.13 v2(89.01,15.53)
EN_PP3300_G_R: length 83.7
  TOP w0.109: v2(90.3,15.53) 90.1,15.33 90.1,13.24 89.71,12.85 89.21,12.85 88.72,12.36 87.72,12.36 87.43,12.65 87.43,13.44 87.3,13.57 Q18.3 ; v2(41.67,46.65) 41.42,46.9 R299.1 R298.1 40.66,46.67 41.1,46.23 R300.1
  IN4 w0.089: v2(90.3,15.53) 86.46,19.37 83.42,19.37 82.44,18.39 72.44,18.39 68.81,22.02 68.81,27.21 70.59,29 70.59,30.58 69.7,31.48 69.7,38.88 68.79,39.78 62.42,39.78 61.74,40.46 51.31,40.46 45.36,46.42 41.9,46.42 v2(41.67,46.65)
EN_PP3300_INA_ODL: length 2.9
  TOP w0.079: 168.03,17.85 167.77,18.11 167.77,18.82 U13.J1
  TOP w0.109: R1022.1 168.81,18.17 168.47,17.84 TP66.1 168.03,17.85
EN_PP3300_PANEL_S0: length 88
  TOP w0.089: U1JSL.CC17 105.75,66.39 105.55,66.59 105.55,66.76 v1(105.55,66.76)
  TOP w0.109: U23.5 38.21,49.63 v2(38.32,49.52)
  IN1 w0.097: v2(39.52,57.85) 39.91,57.45 45.85,57.45 46.12,57.72 47.64,57.72 48.21,57.15 48.21,56.82 49.47,55.56 50.56,55.56 50.82,55.81 50.82,56.32 51.4,56.91 52.04,56.91 52.34,57.21 52.34,58.8 54.39,60.84 55.09,60.84 55.68,61.44 60.88,61.44 61.51,62.08 64.8,62.08 65.98,60.89 75.46,60.89 77.62,63.05 77.62,63.74 79.92,66.05 86.04,66.05 86.79,66.8 90.45,66.8 v2(91.18,67.52)
  IN2 w0.097: v2(39.52,57.85) 39.09,57.42 39.09,55.23 39.13,55.18 39.13,50.34 v2(38.32,49.52)
  BOTTOM w0.089: 101.31,67.3 101.33,67.33 101.91,67.33 102.53,66.71 v4(102.81,66.71) 103.04,66.48 103.15,66.48 103.3,66.32 103.68,66.32 103.78,66.23 103.78,66.03 104.04,65.77 104.37,65.77 104.6,66 104.6,66.08 104.81,66.29 R22.1 105.98,66.46 105.68,66.76 v1(105.55,66.76)
  BOTTOM w0.114: 101.31,67.3 100.81,67.3 100.31,67.8 95.06,67.8 94.83,68.03 92.37,68.03 91.94,67.6 91.25,67.6 v2(91.18,67.52)
EN_PP3300_SD_U: length 110.8
  TOP w0.089: 97.05,63.46 97.73,63.46 98.12,63.85 99.88,63.85 99.96,63.94 100.37,63.94 100.56,63.79 100.73,63.79 101.02,63.97 U1JSL.CN22
  TOP w0.109: v2(94.23,63.36) 94.26,63.36 94.54,63.64 95.01,63.64 95.2,63.46 97.05,63.46 ; U34.4 19.89,30.21 20.34,30.65 R287.1 19.9,30.85 v2(19.79,30.95)
  IN1 w0.097: v2(26.05,40.45) 26.21,40.3 27.55,40.3 27.83,40.57 27.83,44.96 30.89,48.02 30.89,48.27 31.41,48.79 31.41,49.36 31.7,49.66 32.95,49.66 37.71,54.42 38.54,54.42 39.59,55.47 43.87,55.47 44.09,55.69 46.63,55.69 47.77,54.54 51.07,54.54 51.33,54.8 53.49,54.8 55.21,53.07 60.81,53.07 61.25,52.62 71.33,52.62 75.69,56.98 77.13,56.98 79.64,59.49 79.64,60.9 80.52,61.78 82.57,61.78 83.07,61.28 84.07,61.28 85.34,62.55 85.34,63.23 87.48,65.37 91.68,65.37 93.69,63.36 v2(94.23,63.36)
  IN4 w0.089: v2(19.79,30.95) 19.98,30.77 23.74,30.77 26.05,33.08 v2(26.05,40.45)
EN_PP3300_TOUCH_S0: length 85.8
  TOP w0.089: U1JSL.CL19 102.14,65.11 101.94,65.3 101.71,65.3 101.46,65.06 101.34,65.01 101.33,65 100.98,65 100.79,64.88 100.59,64.88 100.52,64.95 99.88,64.95 99.49,64.57 98.89,64.57 v2(98.49,64.97)
  TOP w0.109: U35.1 31.24,51.8 31.77,51.27 32.17,51.27 32.36,51.46 32.36,51.97 33.07,52.67 R302.1 33.61,52.87 v2(33.64,52.89)
  IN1 w0.097: v2(33.64,52.89) 35.71,52.89 37.61,54.8 38.54,54.8 39.43,55.69 43.71,55.69 43.93,55.92 46.78,55.92 47.9,54.8 50.89,54.8 51.67,55.57 53.09,55.57 55.39,53.27 61.08,53.27 61.49,52.87 71.18,52.87 75.34,57.03 75.34,58.88 78.44,61.98 82.66,61.98 83.15,61.48 83.99,61.48 85.14,62.63 85.14,63.31 87.41,65.57 91.76,65.57 92.37,64.96 v2(93.29,64.96)
  BOTTOM w0.114: v2(93.29,64.96) 93.29,65.76 93.57,66.05 94.41,66.05 94.93,66.56 96.64,66.56 97.82,65.39 98.06,65.39 v2(98.49,64.97)
EN_PP5000_PEN: length 72.6
  TOP w0.079: U17.J3 155.51,21.42 155.51,20.92 155.72,20.71 155.97,20.71 156.15,20.54 156.15,18.82
  TOP w0.109: 156.15,18.82 156.15,18.68 157.24,17.59 157.24,17.57 157.77,17.04 157.97,17.04 v2(158.67,16.34)
  IN2 w0.097: v2(158.67,16.34) 159.23,15.78 161,15.78 162.83,17.62 165.31,17.62 165.82,18.13 165.82,22.49 167.77,24.43 167.77,26.01 168.09,26.33 168.42,26.33 168.67,26.58 168.67,27.79 170.67,29.78 170.67,31.29 171.1,31.72 184.23,31.72 185.65,33.14 185.65,37.51 187.51,39.37 188.11,39.37 189.15,40.41 189.15,52.67 v2(190.66,54.18)
  BOTTOM w0.114: v2(190.66,54.18) 190.87,54.18 190.9,54.15 J12.13
EN_PP5000_U: length 148.6
  TOP w0.079: v1(156.36,28.56) 156.36,28.38 156.13,28.16 156.13,27.23 U17.K11
  TOP w0.114: R463.1 43.88,36.93 44.21,37.27 v2(47.39,37.27)
  IN2 w0.097: v1(156.36,28.56) 156.36,28.89 156.02,29.23 149.85,29.23 148.81,30.26 143.91,30.26 140.06,26.41 138.11,26.41 135.81,24.12 133.93,24.12 132.67,22.86 131.11,22.86 130.72,22.46 127.05,22.46 126.44,23.07 114.11,23.07 113.9,23.28 v2(112.02,23.28)
  IN4 w0.089: v2(108.73,12.03) 108.73,12.02 108.73,12 108.41,11.68 85.67,11.68 84.66,12.69 84.66,15.56 84.36,15.86 78.3,15.86 77.54,15.1 70.82,15.1 69.7,16.21 69.7,17.25 66.24,20.71 66.24,26.88 59.8,33.32 53,33.32 49.04,37.27 v2(47.39,37.27)
  BOTTOM w0.114: v2(108.73,12.03) 109.19,12.48 109.19,14.84 109.47,15.12 111.03,15.12 114.32,18.42 114.32,20.98 v2(112.02,23.28)
EN_SLP_Z: length 78.9
  TOP w0.079: U17.J7 v1(155.51,24.67)
  TOP w0.109: R297.1 C300.1 92.6,12.23 92.4,12.44 Q19.2 91.8,12.44 91.39,12.85 91.39,15.43 v2(91.49,15.53)
  IN1 w0.097: v2(97.93,16.71) 97.53,17.12 92.29,17.12 91.49,16.31 v2(91.49,15.53)
  IN4 w0.079: v1(155.51,24.67) 155.19,24.99 153.34,24.99 153.31,24.95
  IN4 w0.089: v2(97.93,16.71) 97.93,18.6 98.82,19.49 101.29,19.49 102.07,18.72 110.46,18.72 111.7,17.48 132.7,17.48 132.87,17.31 144.98,17.31 148.38,20.71 148.4,20.71 148.43,20.74 149.2,20.74 150.22,21.76 150.22,23.15 150.44,23.38 150.44,24.45 150.94,24.95 153.31,24.95
EN_SPK: length 137.9
  TOP w0.089: v2(103.42,65.94) 103.82,65.54 U1JSL.CH19
  TOP w0.109: R91329.1 R183.1 22.49,17.71 v2(23.01,18.23) ; v2(26.15,9.21) R91332.1
  IN1 w0.097: v2(64.46,45.43) 63.47,45.43 60.81,42.76 49.91,42.76 45.59,38.44 31.88,38.44 20.84,27.39 20.06,27.39 17.42,24.75 17.42,19.06 18.25,18.23 v2(23.01,18.23)
  IN4 w0.089: v2(26.15,9.21) 24.38,10.98 23.26,10.98 22.37,11.87 22.37,17.59 v2(23.01,18.23)
  BOTTOM w0.089: 102.19,66.05 102.68,65.55 102.98,65.55 103.37,65.94 v2(103.42,65.94)
  BOTTOM w0.114: 102.19,66.05 101.92,66.31 101.28,66.31 101.05,66.54 100.86,66.54 100.09,67.31 94.53,67.31 94.31,67.53 93.67,67.53 93.47,67.33 93.47,67.04 93.27,66.84 92.33,66.84 92.28,66.89 89.78,66.89 89.68,66.99 87.86,66.99 87.48,66.61 86.86,66.61 84.95,64.71 84.95,64.41 84.94,64.38 84.92,64.34 84.36,63.78 v4(84.36,59.6) 83.46,59.6 80.33,56.48 80.33,56.18 77.72,53.56 72.57,53.56 70.88,51.88 65.17,51.88 63.52,50.23 63.52,46.16 64.25,45.43 v2(64.46,45.43)
EN_USB_A0_VBUS: length 162.4
  TOP w0.079: U17.C2 150.97,20.78 150.97,20.33 150.74,20.1 150.74,19.72 150.4,19.38
  TOP w0.109: 150.4,19.38 v4(150.21,19.19) 149.82,18.8 149.82,18.53 v1(149.24,17.95) ; U37.5 25.33,59.51 25.59,59.25 R375.1 25.59,58.24 25.86,57.97 27.35,57.97 27.69,58.32 34.36,58.32 34.45,58.41 35.15,58.41 v2(35.58,57.97)
  IN4 w0.089: v2(35.58,57.97) 35.45,57.85 35.45,56.56 41.66,50.35 44.18,50.35 51.35,43.19 62.2,43.19 62.65,42.73 70.28,42.73 71.97,41.05 71.97,38.12 73.46,36.63 73.46,27.71 72.47,26.72 72.47,24.22 74.19,22.5 76.48,22.5 77.34,21.64 83.17,21.64 84.61,20.2 89.82,20.2 91.61,18.41 91.61,16.22 92.26,15.57 95.44,15.57 95.79,15.23 102.61,15.23 103.03,15.64 110.33,15.64 111.28,14.69 143.65,14.69 143.99,15.03 146.78,15.03 149.24,17.49 v1(149.24,17.95)
EN_USB_A1_VBUS: length 80.1
  TOP w0.079: U17.E11 152.59,26.94 152.29,27.24 152.29,28.18 v1(151.91,28.56)
  IN2 w0.097: v2(169.03,26.2) 168.64,25.8 168.64,24.47 169.21,23.9 169.21,21.96 169.89,21.27 172.85,21.27 173.84,20.29 174.83,20.29 177.84,23.3 184.28,23.3 190.55,29.57 190.55,49.19 191.6,50.24 192.03,50.24 192.17,50.38 192.17,51.24 v2(191.8,51.61) ; v2(166.77,30.64) 166.74,30.64 165.84,29.74 165.02,29.74 163.94,28.66 157.29,28.66 156.4,27.77 154.96,27.77 154.7,28.02 154.7,28.76 154.44,29.03 152.16,29.03 151.91,28.77 v1(151.91,28.56)
  IN4 w0.089: v2(166.77,30.64) 166.85,30.64 167.61,29.88 167.61,29.2 169.08,27.72 169.08,26.25 v2(169.03,26.2)
  BOTTOM w0.114: J12.16 192.84,52.65 v2(191.8,51.61)
EN_V1P05EXT: length 5.5
  TOP w0.254: U33.6 59.52,38.58 59.19,38.9 v2(59.19,39.1)
  BOTTOM w0.203: R290.2 56.99,36.4 57,36.41 D26.2 57,37.5 57.81,38.31 58.4,38.31 v2(59.19,39.1)
EN_VCCIO_EXT: length 100.3
  TOP w0.079: U17.L3 156.75,21.74 157.12,21.37 157.68,21.37 v1(158.16,21.86)
  TOP w0.109: v2(172.52,76.02) 172.52,77.36 169.41,80.47 163.89,80.47 R452.1
  IN1 w0.097: v2(172.52,76.02) 173.25,75.29 173.25,72.41 189.16,56.49 189.16,41.28 188.74,40.86 188.74,33.13 184.18,28.57 184.17,28.57 180.75,25.16 177.34,25.16 174.94,22.75 174.33,22.75 172.72,21.15 164.81,21.15 163.55,22.41 158.71,22.41 v1(158.16,21.86)
EN_VCCIO_EXT_R: length 9
  TOP w0.109: U38.3 163.56,77.75 163.64,77.84 163.64,78.29 163.72,78.37 163.72,78.98 163.34,79.36 R452.2 163.5,79.47 164.03,80 165.32,80 165.63,79.69 v4(166.77,79.69) 166.77,79.31 166.99,79.08 R453.2 167.79,78 D40.2
EN_VCCST: length 149.9
  TOP w0.079: U17.G12 153.89,27.8 153.56,28.13 v1(153.56,28.56)
  TOP w0.109: Q28.3 64.85,65.14 65.03,64.96 R254.1 65.93,64.96 v2(66.31,64.58) 66.79,65.05 U27.D2
  IN2 w0.097: v1(153.56,28.56) 152.97,27.97 150.43,27.97 148.33,30.06 143.99,30.06 140.13,26.2 138.2,26.2 135.92,23.92 134.02,23.92 132.75,22.66 131.21,22.66 130.82,22.26 126.95,22.26 126.34,22.87 110.42,22.87 110.04,23.25 v2(110.04,23.28)
  IN4 w0.089: v2(109.52,16.22) 109.14,15.84 102.88,15.84 102.46,15.42 95.86,15.42 95.52,15.76 92.34,15.76 91.8,16.3 91.8,18.5 89.91,20.39 84.69,20.39 83.25,21.84 77.45,21.84 76.57,22.72 74.31,22.72 72.67,24.36 72.67,26.56 74.54,28.44 74.54,34.84 76.82,37.11 76.82,45.55 75.51,46.86 75.51,51.1 72.09,54.52 72.09,61.65 71.42,62.32 70.3,62.32 68.49,64.13 67.53,64.13 67.26,64.4 66.49,64.4 v2(66.31,64.58)
  BOTTOM w0.114: v2(110.04,23.28) 110.04,21.4 109.52,20.87 v2(109.52,16.22)
EN_VCCST_ODL: length 21.2
  TOP w0.109: D31.2 70,69.78 67.58,67.37 66.69,67.37 65.19,65.87 Q28.2 64.59,66.16 65.12,66.69 65.12,67.09 R253.2 64.76,67.78 64.66,67.88 63.9,67.88 63.65,67.63 63.65,66.36 63.3,66.01 Q24.3 Q25.3 Q27.3 Q26.3
EN_VNNEXT: length 8.2
  TOP w0.254: R240.2 60.09,33.63 v2(59.62,34.1) 59.52,34.19 U33.15
  BOTTOM w0.254: D26.1 55.1,36.36 55.83,35.63 56.5,35.63 58.58,33.55 59.3,33.55 59.62,33.87 v2(59.62,34.1)
ESPI_CLK: length 118.5
  TOP w0.109: v1(158.49,19.51) 158.07,19.51 U17.M1 ; v2(90.98,28.89) 85.92,28.89 v4(84.43,30.38) 83.18,31.63 83.18,43.79 88.12,48.73 88.12,50.66 88.81,51.35 88.81,52.51 91.79,55.49 91.79,56.22 93.46,57.9 95.31,57.9 95.38,57.82 R353.2
  IN1 w0.097: v2(90.98,28.89) 90.98,28.62 91.89,27.71 91.91,27.71 94.26,25.36 95.14,25.36 97.18,23.31 105.67,23.31 106.13,22.86 112.33,22.86 117.09,18.11 119.89,18.11 122.8,15.2 147.27,15.2 148.37,16.29 150.6,16.29 151.2,16.89 154.17,16.89 155.58,18.3 156.83,18.3 158.03,19.51 v1(158.49,19.51)
ESPI_CLK_R: length 5.5
  TOP w0.089: R353.1 96.45,58.19 96.8,58.19 96.82,58.22 v4(97.21,58.22) 97.73,58.22 97.88,58.07 100.4,58.07 100.62,58.21 100.79,58.21 101.09,58.06 U1JSL.CN35
ESPI_CS_L: length 119.7
  TOP w0.079: U17.L1 156.33,20.28 156.33,19.86 v1(156.69,19.51)
  TOP w0.089: U1JSL.CR35 100.67,57.89 97.42,57.89 97.34,57.81 v2(96.69,57.81)
  IN1 w0.097: v2(121.01,21.37) 121.01,20.48 123.98,17.51 146.09,17.51 149.17,20.59 152.01,20.59 152.21,20.38 153.33,20.38 153.84,20.89 155.85,20.89 156.36,20.38 156.36,19.84 v1(156.69,19.51)
  IN4 w0.089: v2(121.01,21.37) 120.55,21.83 120.28,21.83 119.92,21.47 119.42,21.47 119.06,21.83 116.12,21.83 115.75,21.46 108.22,21.46 107.68,20.92 106.81,20.92 105.85,21.88 95.42,21.88 93.66,23.65 91.58,23.65 86.28,28.95 86.28,36.76 86.07,36.97 86.07,48.23 89.06,51.22 89.06,52.38 93.91,57.23 96.11,57.23 v2(96.69,57.81)
  BOTTOM w0.117: v2(96.69,57.81) 96.61,57.81 96.38,57.59 R11120.1
ESPI_IO0: length 113.6
  TOP w0.079: U17.H1 154.42,20.33 154.42,19.83 v1(154.78,19.47)
  TOP w0.109: v2(91.61,28.74) 91.27,28.4 85.7,28.4 v4(83,31.1) 82.69,31.41 82.69,44 87.63,48.93 87.63,50.66 88.32,51.35 88.32,52.71 91.29,55.68 91.29,56.22 93.37,58.29 R70.2
  IN1 w0.097: v1(154.78,19.47) 154.78,18.67 153.82,17.71 150.74,17.71 150.18,17.16 148.06,17.16 146.97,16.07 123.1,16.07 119.4,19.77 116.6,19.77 112.22,24.14 97.52,24.14 95.48,26.18 94.62,26.18 92.07,28.74 v2(91.61,28.74)
ESPI_IO0_R: length 7.3
  TOP w0.089: U1JSL.CP34 101.03,58.58 100.54,58.58 100.29,58.42 98.38,58.42 97.74,59.06 96.76,59.06 96.6,58.9 96.21,58.9
  TOP w0.109: R70.1 94.7,58.29 v4(95.31,58.9) 96.21,58.9
ESPI_IO1: length 118.2
  TOP w0.079: U17.J1 155.19,19.5 v1(155.75,18.94)
  TOP w0.109: R343.2 95.09,59.32 94.45,58.69 93.24,58.69 90.8,56.24 90.8,55.7 87.96,52.86 87.96,51.5 87.26,50.81 87.26,49.08 82.33,44.15 82.33,31.11 v4(84.45,28.99) 85.4,28.04 91.8,28.04 v2(92.02,28.26)
  IN1 w0.097: v2(92.02,28.26) 92.05,28.26 94.48,25.83 95.34,25.83 97.38,23.79 112.08,23.79 117.28,18.59 120.08,18.59 122.97,15.7 147.1,15.7 148.19,16.79 150.31,16.79 150.88,17.36 153.97,17.36 155.54,18.94 v1(155.75,18.94)
ESPI_IO1_R: length 6.3
  TOP w0.089: R343.1 96.61,59.32 96.7,59.24 97.81,59.24 97.87,59.18 98.72,59.18 98.73,59.17 98.77,59.17 99.04,58.9 100.34,58.9 100.52,58.77 100.74,58.77 100.78,58.77 100.98,58.89 101.13,58.89 101.26,58.84 102.02,58.84 U1JSL.CL33
ESPI_IO2: length 110.7
  TOP w0.079: v1(154.81,20) 154.81,20.82 U17.H2
  TOP w0.109: R344.2 93.45,57.43 92.28,56.26 92.28,55.29 89.3,52.31 89.3,51.15 88.61,50.46 88.61,48.52 83.67,43.59 83.67,31.84 v4(86.12,29.4) v2(90.47,29.4)
  IN1 w0.097: v1(154.81,20) 154.45,19.65 154.45,19.01 154.04,18.6 151.49,18.6 151.05,19.05 149.13,19.05 146.52,16.44 123.3,16.44 119.61,20.14 116.72,20.14 112.37,24.49 97.67,24.49 95.63,26.53 94.77,26.53 91.91,29.4 v2(90.47,29.4)
ESPI_IO2_R: length 8.7
  TOP w0.089: 97.26,57.43 97.54,57.71 100.52,57.71 100.59,57.64 100.79,57.64 100.98,57.76 101.33,57.76 101.34,57.76 101.34,57.77 101.37,57.78 101.46,57.82 101.68,58.04 101.92,58.04 102.1,57.86 U1JSL.CL36
  TOP w0.109: 97.26,57.43 v4(94.71,57.43) R344.1
ESPI_IO3: length 114.5
  TOP w0.079: U17.K1 155.84,20.12 v1(155.72,20)
  TOP w0.109: v2(90.06,29.91) 86.12,29.91 84.04,31.99 84.04,43.44 88.97,48.37 88.97,50.31 89.66,51 89.66,51.68 89.68,51.69 89.68,52.17 92.68,55.17 92.68,56.12 93.58,57.02 95.18,57.02 95.23,57.08 95.86,57.08 95.88,57.05 R352.2
  IN1 w0.097: v2(90.06,29.91) 92,29.91 94.29,27.62 95.04,27.62 97.82,24.84 112.51,24.84 116.53,20.82 117.92,20.82 118.21,21.11 118.21,21.43 118.31,21.52 118.52,21.52 118.62,21.43 118.62,21.11 118.71,21.02 118.92,21.02 119.02,21.11 119.02,21.43 119.11,21.52 119.32,21.52 119.42,21.43 119.42,21.11 119.51,21.02 119.51,20.8 123.5,16.81 146.37,16.81 148.97,19.42 151.22,19.42 151.66,18.98 153.99,18.98 154.2,19.19 154.2,19.75 154.48,20.03 154.48,20.14 154.67,20.33 155.39,20.33 v1(155.72,20)
ESPI_IO3_R: length 5.3
  TOP w0.089: U1JSL.CM36 101.43,57.61 101.4,57.58 101.03,57.58 100.84,57.46 100.52,57.46 100.45,57.53 100.07,57.53 97.75,57.53 97.55,57.34
  TOP w0.097: 97.26,57.05 97.55,57.34
  TOP w0.109: R352.1 97.26,57.05
ESPI_RESET_L: length 127.5
  TOP w0.079: U17.K3 156.15,21.43 156.66,21.43 156.79,21.3 156.79,20.92 156.99,20.71 157.86,20.71 158.33,20.25
  TOP w0.089: U1JSL.CN34 101.09,58.31 100.99,58.31 100.79,58.4 100.59,58.4 100.35,58.24 98.15,58.24 97.71,58.69 v2(97.58,58.69)
  TOP w0.109: R11114.1 96.93,58.56 97.06,58.69 v2(97.58,58.69) ; v1(158.49,20.09) 158.33,20.25
  IN1 w0.097: v1(158.49,20.09) 157.69,20.09 157.24,19.65 157.24,19.39 156.96,19.11 156.51,19.11 156.16,19.46 156.16,20.3 155.76,20.69 153.92,20.69 153.38,20.15 151.92,20.15 151.71,20.37 149.23,20.37 146.17,17.31 123.75,17.31 120.41,20.65 v2(120.41,21.37)
  IN4 w0.089: v2(120.41,21.37) 120.32,21.27 119.32,21.27 118.95,21.64 116.33,21.64 115.96,21.27 108.33,21.27 107.79,20.73 106.72,20.73 105.75,21.69 95.34,21.69 93.58,23.46 91.5,23.46 86.06,28.89 86.06,36.19 85.29,36.97 85.29,47.71 88.79,51.22 88.79,52.38 93.83,57.42 95.73,57.42 97,58.69 v2(97.58,58.69)
FLASH_WP_ODL: length 17.5
  TOP w0.079: 164,24.54 164,23.74 164.1,23.64 164.1,23.34 164.24,23.2 164.24,21.84 U13.B6
  TOP w0.109: R152.2 165.03,32.11 v4(165.12,32.19) ; R152.2 165.03,31.11 165.42,30.72 v2(165.45,30.72) ; R152.2 165.66,31.41 165.69,31.38 D20.1 166.17,30.81 166.08,30.71 Q4.2 166.16,29.98 166.64,29.49 166.64,28.72 166.53,28.6 165.85,28.6 165.61,28.36 163.97,28.36 163.72,28.11 163.72,27.6 163.7,27.57 163.7,27.27 164.23,26.73 164.23,25.72 164,25.49 164,24.54
  BOTTOM w0.114: U41.2 165.47,32.1 165.47,30.75 v2(165.45,30.72)
GP_C13_UART1_TXD: length 10.5
  TOP w0.089: v1(104.91,69.53) 105.23,69.21 U1JSL.CE11
  BOTTOM w0.089: 101.35,68.87 101.59,68.62 102.81,68.62 103.37,69.18 104,69.18 104.12,69.06 104.5,69.06 104.91,69.46 v1(104.91,69.53)
  BOTTOM w0.114: R4E63.2 96.59,69.91 96.98,70.3 97.98,70.3 98.28,70.01 100.5,70.01 v4(100.6,69.91) 100.6,69.61 101.35,68.87
GP_E14_DDI0_DDC_SDA: length 1.7
  TOP w0.109: U1JSL.CM5 102.13,71.57 102.23,71.67 v1(102.23,71.67)
  BOTTOM w0.114: R6D46.2 102.38,71.82 v1(102.23,71.67)
GP_E16_DDI1_DDC_SDA: length 1.3
  TOP w0.109: U1JSL.CN4 101.75,72.04 v2(101.91,72.2)
  BOTTOM w0.114: v2(101.91,72.2) 101.62,72.49 R6D42.2
GPD_1_ACPRESENT: length 9.1
  TOP w0.089: R354.2 102.19,45.95 102.77,45.95 102.97,46.15 104.17,46.15 107.11,49.1 107.11,50.1 107.07,50.14 107.07,50.73 106.91,50.98 106.91,51.47 U1JSL.CA50
GPD_7: length 18
  TOP w0.089: U1JSL.CB51 106.22,51.06 106.22,50.45 106,50.24 106,48.74 103.95,46.69 102.75,46.69 102.55,46.49 101.68,46.49 101.31,46.85 100.36,46.85 100.25,46.74
  TOP w0.109: 94,46.74 100.25,46.74 ; R7D26.2 91.85,46.79 v4(91.71,46.92)
  TOP w0.117: 94,46.74 93.94,46.79 R7D24.1 R7D26.2
GPPC_A_15: length 6.5
  TOP w0.089: 96.64,61.22 96.87,60.98 97.21,60.98 97.49,60.71 98.76,60.71 98.88,60.82 100.58,60.82 100.77,61.01 U1JSL.CP29
  TOP w0.109: R3C14.2 95.19,61.15 95.8,61.15 95.87,61.22 96.64,61.22
GPPC_C_1: length 4.8
  TOP w0.089: 98.44,68.26 98.9,68.26 99.31,67.86 100.76,67.86 100.77,67.85 101.15,67.85 U1JSL.CN14
  TOP w0.109: 98.44,68.26 97.55,68.26 97.17,68.64 R7D35.2
GPPC_C_2: length 9.8
  TOP w0.089: U1JSL.CE15 104.9,67.62 v1(104.9,67.68)
  BOTTOM w0.089: 100.98,68.17 101.12,68.03 104.55,68.03 v1(104.9,67.68)
  BOTTOM w0.114: R8A7.2 96.73,68.94 97.6,68.94 97.73,69.06 v4(98.52,69.06) 98.68,69.22 99.81,69.22 100.31,68.72 100.43,68.72 100.98,68.17
GPPC_C_8_UART0_RXD: length 6.7
  TOP w0.089: U1JSL.CL11 102.44,69 101.8,69 101.52,68.71 101.2,68.71 101.14,68.77 100.55,68.77 100.5,68.72 100.09,68.72 99.77,69.04 98.45,69.04
  TOP w0.109: 98.45,69.04 97.91,69.04 97.54,69.42 96.55,69.42 R7D25.2
GPPC_C_9_UART0_TXD: length 4.3
  TOP w0.089: U1JSL.CR11 100.06,69.4 98.87,69.4 98.69,69.58
  TOP w0.109: R7D40.2 97.5,70.77 98.69,69.58
GPPC_C_10_UART0_RTSB: length 14.9
  TOP w0.089: R4F23.2 95.12,70.62 95.32,70.42 96.23,70.42 v2(96.61,70.8) ; U1JSL.CM11 101.71,68.52 101.14,68.52 101.06,68.59 100.67,68.59 100.62,68.54 100.02,68.54 99.72,68.84 99.02,68.84 98.95,68.77
  TOP w0.109: 98.95,68.77 97.81,68.77 97.36,69.22 96.11,69.22 95.86,69.48 95.55,69.48 R4F20.1 95.11,70.07 94.99,70.19 R4F23.2
  BOTTOM w0.114: R42.1 93.26,73.16 95.62,70.8 v2(96.61,70.8)
GPPC_D_8_GSPI2_CS0B_UART0A_RXD: length 47.4
  TOP w0.089: U1JSL.CM14 101.63,67.42 101.47,67.26 101.08,67.26 100.84,67.12 100.52,67.12 100.39,67.24 98.51,67.24
  TOP w0.109: v2(92.87,70.17) 93.04,70 93.04,68.57 92.95,68.49 R6D34.2 93.83,68.29 94.36,67.75 94.89,67.75 94.99,67.65 R6D29.1 95.65,67.37 95.78,67.24 98.51,67.24
  IN4 w0.089: v2(74.29,67.68) 74.29,67.65 74.06,67.42 74.06,66.96 72.68,65.58 72.68,60.96 73.41,60.22 76.75,60.22 79.43,62.9 79.55,62.9 87.45,70.8 90.37,70.8 91,71.44 92.09,71.44 92.84,70.69 92.84,70.19 v2(92.87,70.17)
  BOTTOM w0.114: R30.2 73.55,69.53 73.55,69.09 R33.2 74.29,68.35 v2(74.29,67.68)
GPPC_D_9_GSPI2_CLK_UART0A_TXD: length 8
  TOP w0.089: 98.39,66.99 99.78,66.99 100.06,66.71 100.43,66.71 100.48,66.77 100.73,66.77 100.89,66.67 101.37,66.67 101.63,66.49 U1JSL.CM16
  TOP w0.109: R1G3.2 R1G1.1 95.29,66.7 95.59,66.99 98.39,66.99
GPPC_D_10_GSPI2_MISO_UART0A_RTS: length 4.8
  TOP w0.089: R6D38.1 R6D41.2 ; U1JSL.CR16 100.6,66.53 99.98,66.53 99.7,66.81 98.82,66.81 98.71,66.71 98.33,66.71
  TOP w0.109: R6D41.2 96.8,66.71 98.33,66.71
GPPC_D_11_GSPI2_MOSI_UART0A_CTS: length 5.7
  TOP w0.089: U1JSL.CN17 101.04,66.38 100.73,66.19 100.56,66.19 100.35,66.35 99.91,66.35 99.63,66.64 98.9,66.64 98.73,66.47 98.1,66.47
  TOP w0.109: R1H18.2 96.87,65.42 96.97,65.52 97.15,65.52 v4(97.2,65.57) 97.2,65.97 97.7,66.47 98.1,66.47
GPPC_E_6_IMGCLKOUT_3: length 2.8
  TOP w0.089: v2(103.94,71.86) U1JSL.CH7
  BOTTOM w0.109: R6C1.2 103.14,72.75 v4(103.43,72.46) 103.84,72.46 103.94,72.36 v2(103.94,71.86)
GPPC_E_12_IMGCLKOUT_4: length 4
  TOP w0.109: v1(101.8,71.11) 102.36,70.55 U1JSL.CL8
  BOTTOM w0.109: v1(101.8,71.11) 101.8,71.66 101.35,72.11 100.97,72.11 v4(100.68,71.82) 100.68,72.23 100.88,72.43 R6D39.2
H1_AP_FLASH_SEL: length 30
  TOP w0.109: R357.1 R360.1 171.49,19.7 v1(171.77,19.42)
  IN1 w0.097: v2(166.77,30.03) 167.4,30.03 168.55,31.18 v2(169.11,31.18)
  BOTTOM w0.114: U42.1 169.89,31.81 169.59,31.51 169.44,31.51 v2(169.11,31.18) ; Q5.2 173.37,17.93 171.87,19.42 v1(171.77,19.42) 171.77,19.11 171.09,18.43 171.09,17.71 170.93,17.56 170.15,17.56 168.45,19.26 168.45,20.78 168.08,21.14 166.65,21.14 163.98,23.82 163.98,24.47 164.19,24.69 165.7,24.69 166.16,25.14 166.16,26.63 166.43,26.9 166.43,29.69 v2(166.77,30.03)
H1_AP_FLASH_SEL_ODL: length 8.8
  BOTTOM w0.114: Q6.2 182.41,20.89 182.24,20.71 R55.2 180.95,20.29 180.51,19.85 178.35,19.85 176.93,18.43 Q5.3
H1_AP_INT_ODL: length 126.5
  TOP w0.109: v1(164.1,27.41) 164.18,27.41 164.25,27.47 R62.2 164.66,27.19 164.73,27.13 D10.2 ; U1JSL.CP48 100.37,51.98 100.07,51.98 99.56,52.49 99.14,52.49 98.8,52.83 v2(98.8,52.88)
  IN2 w0.097: v2(98.8,52.88) 98.8,52.84 98.06,52.11 98.06,49.54 96.34,47.82 94.12,47.82 93.33,48.61 90.1,48.61 89.91,48.42 87.78,48.42 84.51,45.15 84.51,30.86 90.73,24.64 98.5,24.64 99.12,24.02 108.55,24.02 109.91,22.66 126.25,22.66 126.84,22.06 130.91,22.06 131.31,22.46 132.84,22.46 134.1,23.72 136,23.72 138.26,25.98 140.19,25.98 144.08,29.87 146.94,29.87 149.24,27.57 156.48,27.57 157.37,28.46 163.05,28.46 v1(164.1,27.41)
H1_AP_INT_ODL_D: length 4.6
  TOP w0.079: 166.52,24.54 166.52,23.76 166.25,23.5 166.25,22.85 U13.F8
  TOP w0.109: D10.1 166.51,26.43 167.02,25.92 167.02,25.64 166.95,25.56 166.95,25.46 166.52,25.03 166.52,24.54
H1_BOOT0_AP_FLASH_SEL: length 4.7
  TOP w0.079: 169,19.75 168.93,19.83 167.77,19.83 U13.J3
  TOP w0.109: v4(170.96,18.93) 170.96,18.98 170.74,19.21 R360.2 170.53,19.49 170.27,19.49 170.1,19.32 169.45,19.32 169.34,19.43 R69.1 169.05,19.7 169,19.75
H1_CC1: length 1.6
  TOP w0.079: v4(165.12,17.69) 165.17,17.74 165.17,18.65 164.9,18.92 164.9,19 U13.D1
H1_CC1_R: length 187.5
  TOP w0.178: v2(41.55,67.75) 41.55,68.31 41.17,68.69 U8.12
  TOP w0.254: v2(163.98,15.84) 163.98,16.05 164.47,16.55 R212.2
  IN4 w0.254: v2(163.98,15.84) 163.98,15.69 162.42,14.14 144.3,14.14 144,13.84 110.87,13.84 109.91,14.81 103.56,14.81 103.09,14.34 95.35,14.34 95.03,14.66 87.41,14.66 86.85,15.22 86.85,17.09 85.71,18.22 83.42,18.22 82.84,17.65 72.14,17.65 68.01,21.77 68.01,27.6 65.99,29.62 65.99,30.7 68.84,33.55 68.84,38.25 68.32,38.77 62.13,38.77 61.28,39.62 56.64,39.62 55.88,38.85 51.1,38.85 44.42,45.53 41.17,45.53 40.53,46.16 40.53,47.05 40.28,47.31 37.86,47.31 35.62,49.55 35.62,53.62 32.67,56.57 32.67,58.62 34.56,60.51 35.98,60.51 36.47,61 36.47,62.67 38.88,65.09 38.88,66.61 40.53,68.26 41.23,68.26 41.55,67.95 v2(41.55,67.75)
H1_CC2: length 1.9
  TOP w0.079: U13.D2 164.74,19.34 164.74,18.85 165,18.6 165,18.24 164.75,17.99
  vias: v4(163.76,17.88)
H1_CC2_R: length 183.8
  TOP w0.178: U8.11 41.01,68.29 41.17,68.13 41.17,68.01 v2(40.91,67.75)
  TOP w0.254: v2(163.34,15.81) 163.34,16.11 163.71,16.48 R213.2
  IN4 w0.254: v2(163.34,15.81) 163.34,15.68 162.19,14.53 144.19,14.53 143.85,14.2 111.04,14.2 110.06,15.17 103.32,15.17 102.88,14.73 95.55,14.73 95.26,15.03 87.56,15.03 87.23,15.36 87.23,17.28 85.9,18.6 83.23,18.6 82.7,18.07 72.36,18.07 68.41,22.03 68.41,27.81 66.49,29.73 66.49,30.54 69.32,33.37 69.32,38.38 68.55,39.15 62.26,39.15 61.41,39.99 56.42,39.99 55.68,39.25 51.67,39.25 45.01,45.91 41.29,45.91 40.91,46.29 40.91,47.31 40.4,47.81 37.99,47.81 35.99,49.82 35.99,53.77 33.04,56.71 33.04,58.36 34.69,60.01 36.15,60.01 36.94,60.79 36.94,62.51 39.39,64.96 39.39,66.48 40.66,67.75 v2(40.91,67.75)
H1_CHASSIS_OPEN: length 37.5
  TOP w0.079: U13.A1 163.5,18.99 163.11,18.6
  TOP w0.109: v1(162.68,15.81) R154.1 C129.1 162.68,17.67 163.11,18.1 163.11,18.6
  BOTTOM w0.114: v1(162.68,15.81) 162.68,14.33 165.05,11.95 176.93,11.95 177.36,12.38 177.36,15.28 181.93,19.85 185.11,19.85 J1.2
H1_EC_FLASH_SEL: length 1.9
  TOP w0.079: U13.J5 167.79,21.1 167.83,21.14 168.95,21.14 169,21.2
  TOP w0.109: R60.1 169.05,21.22 169.03,21.2 169,21.2
H1_EC_PWR_BTN_ODL: length 19
  TOP w0.079: 162.01,24.09 162.12,24.09 162.37,23.84 162.37,23.37 163.39,22.35 163.74,22.35 U13.B7 ; U17.D6 v1(152.26,23.37)
  TOP w0.109: v1(162.31,26.22) 162.58,25.95 162.58,25.48 162.31,25.21 162.02,25.21 161.71,24.9 161.71,24.22 161.84,24.09 162.01,24.09
  IN2 w0.079: 156.74,23.43 156.34,23.04 152.59,23.04 v1(152.26,23.37)
  IN2 w0.097: 156.74,23.43 157.24,23.94 157.24,25.19 157.34,25.28 158.22,25.28 159.47,26.53 162,26.53 v1(162.31,26.22)
H1_KSI: length 4.2
  TOP w0.079: 161.3,20.61 161.43,20.48 162.98,20.48 163.34,20.84 163.67,20.84 163.91,20.6 U13.B4
  TOP w0.109: R3002.1 160.6,21.09 160.88,20.81 R3001.1 161.29,20.62 161.3,20.61
H1_PWR_BTN_ODL: length 8.5
  TOP w0.079: U13.A4 163.21,20.31 161.21,20.31 161.18,20.28
  TOP w0.109: 161.18,20.28 160.88,19.98 R12.2 160.85,20.51 160.7,20.66 159.68,20.66 159.5,20.48 159.5,17.51 159.73,17.29 Q22.1
H1_RST_ODL: length 16.5
  TOP w0.079: R71.2 C62.1 165.93,17.38 v4(166.44,17.89) 166.3,18.03 v1(166.3,18.55) 166.5,18.75 U13.G1
  TOP w0.109: U1.22 171.41,25.56 171.91,25.06 171.91,24.55 172.37,24.09 172.37,22.52 172.88,22.01 172.88,21.07 v1(171.77,19.96)
  IN1 w0.097: v1(166.3,18.55) 166.71,18.15 168.88,18.15 169.23,18.5 170.31,18.5 v1(171.77,19.96)
H1_SBU1: length 191.9
  TOP w0.079: U13.F2 166.24,19.35 166.24,18.99 166.06,18.81 165.79,18.81 U13.E1 165.5,18.76 165.83,18.43 165.83,17.54 165.46,17.17 165.46,17.08 165.47,17.06 165.47,17.04
  TOP w0.097: v2(165.23,15.82) 165.26,15.85 165.26,16.48 165.47,16.7 165.47,17.04 ; R214.2 42.43,69.93 42.52,69.84 42.72,69.84 v2(42.91,70.03) 43.12,69.81 43.29,69.81 43.4,69.93 R216.1
  IN4 w0.097: v2(42.91,70.03) 42.71,69.83 42.57,69.83 42.31,70.09 42.31,70.14 41.8,70.65 41.11,70.65 40.88,70.42 38.34,70.42 37.86,69.95 37.86,67.43 37.22,66.79 33.88,66.79 33.11,66.02 33.11,60.4 31.39,58.67 31.39,57.29 31.75,56.92 31.75,56.21 34.68,53.28 34.68,48.87 38.52,45.02 38.52,44.11 39.4,43.23 44.58,43.23 52.28,35.53 56.53,35.53 57.51,34.55 59.76,34.55 67.07,27.23 67.07,21.14 71.54,16.67 84.7,16.67 85.5,15.88 85.5,14.53 85.91,14.12 86.09,14.12 86.49,13.72 94.51,13.72 95.01,13.22 110.14,13.22 110.54,12.82 163.03,12.82 165.04,14.84 165.04,15.63 v2(165.23,15.82)
H1_SBU2: length 190.6
  TOP w0.079: U13.F1 165.83,19.27 U13.E2 165.25,19.34 165.25,18.94 165.34,18.84 165.34,18.69 165.67,18.36 165.67,17.6 165.3,17.23 165.3,17.08 165.29,17.06 165.29,17.04
  TOP w0.097: 165.29,17.04 165.29,16.78 165.07,16.56 165.07,16.25 164.85,16.03 ; R215.2 42.43,69.53 42.55,69.65 42.68,69.65 v2(42.91,69.43) 43.1,69.62 43.26,69.62 43.4,69.48 R217.1
  TOP w0.102: v2(164.64,15.82) 164.85,16.03
  IN4 w0.097: v2(42.91,69.43) 42.71,69.63 42.49,69.63 42.11,70.01 42.11,70.06 41.72,70.45 41.19,70.45 40.96,70.22 38.42,70.22 38.07,69.86 38.07,67.35 37.31,66.58 33.97,66.58 33.32,65.94 33.32,60.31 31.59,58.58 31.59,57.37 31.95,57.01 31.95,56.29 34.88,53.36 34.88,48.95 38.73,45.11 38.73,44.19 39.49,43.43 44.66,43.43 52.36,35.73 56.61,35.73 57.6,34.75 59.84,34.75 67.27,27.32 67.27,21.23 71.62,16.88 84.79,16.88 85.7,15.96 85.7,14.61 85.99,14.32 86.17,14.32 86.57,13.92 94.59,13.92 95.09,13.42 110.23,13.42 110.62,13.03 162.94,13.03 164.84,14.92 164.84,15.62 v2(164.64,15.82)
H1_SPI_CLK: length 17.6
  TOP w0.079: v1(166.87,24.19) 166.74,24.07 166.74,23.61 166.5,23.37 U13.G9
  BOTTOM w0.109: v1(166.87,24.19) 166.87,22.5 167.16,22.21 169.17,22.21 169.75,21.63 169.75,19.84 170.1,19.49 170.55,19.49 170.78,19.72 170.78,20.2 170.83,20.25 v4(170.83,20.28) 170.83,20.86 170.99,21.02 172.3,21.02 173.32,19.99 175.68,19.99 176.28,20.59 R54.1
H1_SPI_CS_L: length 20.2
  TOP w0.079: U13.J7 167.72,22.31 168.29,22.31 168.85,22.87 v1(168.85,23.2)
  BOTTOM w0.109: v1(168.85,23.2) 169.28,23.63 169.28,23.94 168.6,24.62 168.6,26.92 168.14,27.38 v4(168.14,28.13) 168.14,28.86 167.63,29.37 167.63,31.56 168.04,31.98 169.25,31.98 169.7,32.43 170.96,32.43 ; 170.96,32.43 171.02,32.37 U42.2 ; 170.96,32.43 174.49,32.43 174.81,32.12 R58.1
H1_SPI_MISO: length 19
  TOP w0.079: U13.J9 167.5,23.2 v1(168.04,23.73)
  BOTTOM w0.109: R53.1 176.02,32.12 175.33,32.8 169.54,32.8 169.08,32.34 167.78,32.34 167.26,31.82 167.26,29.22 167.66,28.82 167.66,25.72 168.04,25.33 v4(168.04,24.45) v1(168.04,23.73)
H1_SPI_MOSI: length 19.9
  TOP w0.079: U13.D9 165,23.6 v1(164.92,23.69)
  BOTTOM w0.109: v1(164.92,23.69) 166.89,21.72 v4(168.55,21.72) 168.8,21.72 169.26,21.26 169.26,19.32 170.02,18.55 170.4,18.55 171.28,19.43 171.28,20.01 171.63,20.37 172.23,20.37 173.12,19.48 176.81,19.48 178.22,20.89 R57.1
H1_STRAP0: length 2.9
  TOP w0.079: 165.11,24.54 165.25,24.41 165.25,22.84 U13.D8
  TOP w0.109: 165.11,24.54 165.06,24.59 164.69,24.59 164.5,24.78 R63.2
H1_STRAP1_LID_OPEN_OD: length 6.4
  TOP w0.079: 168.71,24.19 168.66,24.19 168.42,23.95 168.42,23.65 167.61,22.84 167.4,22.84 167.15,22.6 U13.H8
  TOP w0.109: Q15.1 171.51,22.89 171.24,23.17 R65.2 170.46,23.17 170.21,23.42 170.21,23.8 170.05,23.96 169.4,23.96 169.16,24.19 168.71,24.19
H_CATERR_N: length 6.8
  TOP w0.089: U1JSL.AB3 124.45,72.66 124.65,73.14 124.65,73.54 125.04,73.93 125.04,74.4
  TOP w0.109: R8602.2 125.92,78.62 125.47,78.17 125.47,77.31 v4(125.19,77.02) 125.19,76.63 125.04,76.47 125.04,74.4
H_PECI: length 7.8
  TOP w0.089: 120.05,77.62 120.05,77.45 120.33,77.17 120.33,75.31 120.02,75 120.02,73.59 119.91,73.47 119.91,73.14 120.01,73.04 120.01,72.69 119.73,72.42 U1JSL.AM4
  TOP w0.109: R394.1 119.72,78.73 v4(119.83,78.62) 120.05,78.41 120.05,77.62
H_THRMTRIP_N: length 4.8
  TOP w0.089: R8604.2 118.73,76.66 118.75,76.63 v4(118.75,76.22) 118.75,75.78 118.4,75.43 118.4,74.28 118.58,74.1 118.58,73.52 118.69,73.41 118.69,73.13 118.46,72.89 U1JSL.AR3
HDMI_DDC_SCL: length 65.7
  TOP w0.089: U1JSL.CF7 104.33,71.1 v1(104.33,71.45)
  TOP w0.097: v2(162.5,69.66) 162.68,69.83 R148.1
  IN4 w0.097: v1(104.33,71.45) 104.4,71.52 105.13,71.52 105.54,71.93 106.83,71.93 107.05,71.72 107.05,71.26 107.85,70.47 109.8,70.47 110.15,70.12 110.15,69.15 110.56,68.74 112.32,68.74 112.99,69.41 124.15,69.41 124.99,68.57 124.99,68.38 125.84,67.52 133.27,67.52 133.54,67.8 140.05,67.8 141.03,66.82 142.6,66.82 143.45,67.67 158.99,67.67 161.41,70.09 162.48,70.09 162.6,69.97 162.6,69.76 v2(162.5,69.66)
HDMI_DDC_SDA: length 67.3
  TOP w0.089: U1JSL.CF5 104.85,71.41 105,71.56 105,71.72 v2(104.82,71.91)
  TOP w0.097: v2(163.11,69.68) 163.24,69.81 R149.1
  IN4 w0.097: v2(163.11,69.68) 163.06,69.68 162.83,69.91 162.83,70.07 162.58,70.32 161.31,70.32 158.9,67.91 143.35,67.91 142.5,67.05 141.13,67.05 140.15,68.03 133.45,68.03 133.17,67.76 125.94,67.76 125.22,68.47 125.22,68.66 124.24,69.65 112.89,69.65 112.22,68.97 110.65,68.97 110.38,69.25 110.38,70.22 109.9,70.7 107.94,70.7 107.28,71.36 107.28,71.81 106.93,72.16 105.45,72.16 105.04,71.75 104.98,71.75 v2(104.82,71.91)
  BOTTOM w0.097: v2(104.82,71.91) 103.9,72.82 R6D40.2
