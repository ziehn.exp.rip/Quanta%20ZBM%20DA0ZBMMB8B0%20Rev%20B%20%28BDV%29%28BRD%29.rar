# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_A0_ILIM_SEL: length 4.9
  TOP w0.109: U37.4 24.14,58.24 24.35,58.02 R27307.2 R27308.2 24.89,57.49 25.02,57.62 26.31,57.62 26.5,57.43 Q38.3
USB_A0_OC_ODL: length 103.8
  TOP w0.089: R27310.2 94.71,62.55 v2(95.01,62.24)
  TOP w0.109: v2(20.85,60.89) 20.96,61.01 U37.13
  IN1 w0.097: v2(19.32,53.91) 20.49,53.91 22.52,55.94 28.64,55.94 28.94,55.65 31.98,55.65 33.04,56.7 33.04,57.66 33.74,58.35 35.96,58.35 36.47,57.85 38.63,57.85 39.09,57.38 39.09,56.14 39.31,55.92 43.3,55.92 43.58,56.2 46.88,56.2 48.02,55.05 50.82,55.05 51.56,55.79 52.96,55.79 56.53,59.37 56.53,59.68 57.64,60.79 61.11,60.79 61.77,61.44 64.17,61.44 64.53,61.07 64.53,59.92 64.79,59.66 75.8,59.66 78.35,62.21 82.71,62.21 83.22,61.7 83.93,61.7 84.94,62.71 84.94,63.47 87.25,65.78 91.93,65.78 92.36,65.35 93.47,65.35 93.77,65.06 93.77,64.76 94.7,63.82 95.59,63.82 96.74,62.68 96.74,62.28 96.44,61.98 95.27,61.98 v2(95.01,62.24)
  IN4 w0.089: v2(20.85,60.89) 20.85,59.75 19.07,57.97 19.07,56.45 18.43,55.81 18.43,54.8 v2(19.32,53.91)
USB_A0_SSRX_L_N: length 5.6
  TOP w0.097: J10.5 12.1,53.29 12.52,53.71 13.46,53.71 13.71,53.96 14.3,53.96 14.45,53.8 D5.5 D5.6 15.78,53.8 15.94,53.96 16.5,53.96 L7.2
USB_A0_SSRX_L_P: length 5.6
  TOP w0.097: L7.3 16.52,54.14 15.92,54.14 15.76,54.3 D5.7 D5.4 14.45,54.3 14.3,54.14 13.63,54.14 13.38,53.89 12.48,53.89 12.1,54.27 J10.6
USB_A0_SSRX_N: length 119.2
  TOP w0.089: 108.49,77.62 108.49,77.6 108.5,77.6 108.5,76.5 108.09,76.09 108.09,73.74 108,73.64 108,73.23 U1JSL.BV3
  TOP w0.097: v2(42.55,71.66) 42.55,71.74 42.92,72.11 68.03,72.11 72.93,77.01 74.99,77.01 77.8,79.83 84.1,79.83 86.62,82.35 90.63,82.35 91.86,83.57 104.72,83.57 108.49,79.8 108.49,77.62 ; v2(17.81,53.81) 17.7,53.92 17.28,53.92 L7.1
  IN1 w0.097: v2(42.55,71.66) 42.31,71.43 42.31,68.64 41.8,68.13 38.21,68.13 37.65,68.69 36.55,68.69 35.66,67.8 33.9,67.8 32.81,66.71 32.81,61.91 31.12,60.22 26.56,60.22 25.19,58.85 23.18,58.85 22.08,57.75 22.08,57.36 21.7,56.98 19.79,56.98 18.56,55.75 18.56,54.04 18.37,53.85 17.85,53.85 v2(17.81,53.81)
USB_A0_SSRX_P: length 119.2
  TOP w0.089: U1JSL.BV1 108.18,73.33 108.18,73.57 108.27,73.66 108.27,76.02 108.67,76.42 108.67,77.6 108.68,77.6 108.68,77.62
  TOP w0.097: v2(17.81,54.39) 17.52,54.1 17.33,54.1 L7.4 ; v2(41.93,71.66) 42.35,72.08 42.63,72.08 42.84,72.29 67.95,72.29 72.85,77.2 74.91,77.2 77.73,80.01 84.03,80.01 86.54,82.53 90.56,82.53 91.78,83.76 104.8,83.76 108.68,79.88 108.68,77.62
  IN1 w0.097: v2(41.93,71.66) 42.11,71.49 42.11,68.73 41.72,68.34 38.3,68.34 37.74,68.9 36.47,68.9 35.58,68.01 33.82,68.01 32.61,66.8 32.61,62 31.04,60.43 26.48,60.43 25.11,59.05 23.1,59.05 21.87,57.83 21.87,57.45 21.61,57.19 19.71,57.19 18.36,55.84 18.36,54.12 18.29,54.05 18.12,54.05 17.81,54.35 v2(17.81,54.39)
USB_A0_SSTX_C_N: length 1
  TOP w0.097: L8.1 17.32,55.48 17.71,55.48 17.83,55.36 C157.2
USB_A0_SSTX_C_P: length 1
  TOP w0.097: C156.2 17.83,55.76 17.73,55.66 17.3,55.66 L8.4
USB_A0_SSTX_L_N: length 9
  TOP w0.097: L8.2 16.52,55.46 15.92,55.46 15.76,55.3 D5.9 D5.2 14.45,55.3 14.3,55.46 13.94,55.46 13.43,55.96 13.43,58.9 12.63,59.71 12.44,59.71 12.1,59.36 J10.8
USB_A0_SSTX_L_P: length 9
  TOP w0.097: L8.3 16.5,55.64 15.94,55.64 15.78,55.8 D5.10 D5.1 14.45,55.8 14.3,55.64 14.02,55.64 13.62,56.04 13.62,58.98 12.7,59.89 12.45,59.89 12.1,60.24 J10.9
USB_A0_SSTX_N: length 106.3
  TOP w0.089: v1(110.72,70.59) 110.72,70.6 U1JSL.BP6
  TOP w0.097: C157.1 18.28,55.46 18.37,55.56 18.91,55.56 19.04,55.43 v2(19.04,55.28)
  IN1 w0.097: v2(19.04,55.28) 19.28,55.52 19.28,55.81 19.9,56.42 22.1,56.42 22.29,56.62 24.94,56.62 26.55,58.23 31.04,58.23 32.64,59.83 35.79,59.83 37.14,58.48 47.26,58.48 49.43,60.65 51.38,60.65 53.4,62.67 54.37,62.67 55.64,63.94 65.54,63.94 66.05,63.43 70.76,63.43 71.44,64.12 73.4,64.12 75.23,65.95 76.34,65.95 78.52,68.13 85.06,68.13 86.56,69.62 89.74,69.62 90.24,69.12 91.46,69.12 91.99,68.59 95.27,68.59 95.94,67.93 99.83,67.93 101.32,66.43 102.04,66.43 102.93,67.32 107.15,67.32 107.33,67.14 109.86,67.14 110.1,67.38 110.1,70.18 110.33,70.41 110.55,70.41 v1(110.72,70.59)
USB_A0_SSTX_P: length 106.3
  TOP w0.089: U1JSL.BP8 110.62,70.04 v1(110.74,70.04)
  TOP w0.097: v2(19.7,55.31) 19.26,55.75 18.47,55.75 C156.1
  IN1 w0.097: v2(19.7,55.31) 19.48,55.53 19.48,55.72 19.98,56.22 22.18,56.22 22.37,56.41 25.02,56.41 26.64,58.02 31.12,58.02 32.72,59.62 35.71,59.62 37.05,58.28 47.35,58.28 49.52,60.45 51.47,60.45 53.49,62.47 54.45,62.47 55.72,63.74 65.45,63.74 65.96,63.23 70.84,63.23 71.53,63.92 73.48,63.92 75.32,65.75 76.43,65.75 78.6,67.93 85.15,67.93 86.64,69.42 89.65,69.42 90.15,68.92 91.37,68.92 91.91,68.39 95.19,68.39 95.85,67.72 99.74,67.72 101.24,66.23 102.13,66.23 103.02,67.12 107.07,67.12 107.24,66.94 109.95,66.94 110.3,67.3 110.3,70.1 110.42,70.21 110.57,70.21 v1(110.74,70.04)
USB_A0_STATUS_L: length 235.5
  TOP w0.109: U37.9 24.14,62.18 24.33,62.37 24.52,62.37 24.66,62.23 24.66,61.56 24.85,61.36 26.75,61.36 28.28,59.84 v2(28.28,58.75)
  IN4 w0.089: v2(194.63,50.51) 194.63,50.4 194.41,50.18 194.41,24.89 189.48,19.96 182.4,19.96 177.94,15.49 167.71,15.49 164.17,11.96 110.41,11.96 109.77,12.6 107.61,12.6 107.08,12.06 95.37,12.06 94.33,13.1 85.77,13.1 85.04,13.83 85.04,15.73 84.54,16.24 78.11,16.24 77.4,15.53 70.98,15.53 70.19,16.32 70.19,17.37 66.64,20.92 66.64,27.05 59.98,33.71 53.46,33.71 44.39,42.79 39.21,42.79 38.02,43.98 38.02,44.92 34.23,48.71 34.23,53.12 31.61,55.74 30.84,55.74 30.2,56.38 30.2,57.8 29.77,58.23 28.8,58.23 v2(28.28,58.75)
  BOTTOM w0.114: J12.20 194,50.65 194.15,50.51 v2(194.63,50.51)
USB_A0_USB2_L_N: length 8.2
  TOP w0.097: L6.3 17.16,58.14 16.99,58.31 15.98,58.31 15.71,58.05 D2742.2 15.28,58.05 15.09,57.86 14.99,57.86 14.72,58.13 v2(14.72,58.16)
  IN1 w0.097: v2(14.72,58.16) 14.72,58.34 14.64,58.42 14.4,58.42 14.31,58.33 14.31,57.95 14.22,57.86 11.66,57.86 11.19,57.39 11.01,57.39 J10.2
USB_A0_USB2_L_P: length 8.2
  TOP w0.097: L6.2 17.15,57.58 16.98,57.41 16,57.41 15.74,57.67 D2742.1 15.52,57.67 14.84,57.67 v2(14.72,57.55)
  IN1 w0.097: J10.3 10.6,56.52 11.74,57.66 14.62,57.66 v2(14.72,57.55)
USB_A0_USB2_N: length 108.4
  TOP w0.089: 105.25,77.62 105.25,77.6 105.25,77.6 105.25,76.8 105.07,76.62 105.07,73.96 105.45,73.59 105.45,73.15 105.55,73.05 105.55,72.72 105.44,72.62 U1JSL.CE4
  TOP w0.097: 105.25,77.62 105.25,78.18 105.82,78.74 105.82,79.13 105.99,79.3 v4(106.34,79.3) 105.89,79.75 105.89,80.38 103.7,82.57 92.27,82.57 91.03,81.33 87.12,81.33 84.63,78.84 78.23,78.84 75.36,75.97 73.31,75.97 68.47,71.13 45.39,71.13 45.18,70.91 45.18,70.51 v2(45.09,70.42) ; U37.2 23.14,58.22 23.28,58.08 23.28,57.86 23.19,57.77 v2(23.03,57.77)
  IN1 w0.097: v2(23.03,57.77) 23.21,57.95 23.21,58.22 23.42,58.43 25.52,58.43 26.44,59.35 31.01,59.35 33.23,61.56 33.23,66.32 33.9,66.99 41.34,66.99 43.38,69.02 44.54,69.02 45.09,69.58 v2(45.09,70.42)
USB_A0_USB2_P: length 108.4
  TOP w0.089: 105.07,77.62 105.07,77.6 105.07,77.6 105.07,76.87 104.89,76.69 104.89,73.89 105.27,73.51 105.27,73.31 105.05,73.09 105.05,72.93 105.13,72.85 U1JSL.CE2
  TOP w0.097: v2(23.89,57.77) 23.59,57.77 23.46,57.9 23.46,58.05 23.64,58.22 U37.3 ; 105.07,77.62 105.07,78.25 105.64,78.82 105.64,79.2 105.53,79.3 v4(105.07,79.3) 105.33,79.56 105.53,79.56 105.71,79.74 105.71,80.3 103.62,82.39 92.35,82.39 91.1,81.14 87.2,81.14 84.7,78.65 78.31,78.65 75.44,75.78 73.39,75.78 68.54,70.94 45.47,70.94 45.36,70.83 45.36,70.73 45.67,70.42 v2(45.74,70.42)
  IN1 w0.097: v2(45.74,70.42) 45.74,70.29 45.62,70.17 45.38,70.17 45.29,70.08 45.29,69.49 44.62,68.82 43.46,68.82 41.43,66.79 33.99,66.79 33.43,66.23 33.43,61.48 31.09,59.14 26.52,59.14 25.61,58.23 23.51,58.23 23.41,58.13 23.41,57.85 23.49,57.77 v2(23.89,57.77)
USB_A0_USB2_U_N: length 9.8
  TOP w0.097: U37.11 23.14,62.28 23.38,62.53 23.38,62.67 23.23,62.81 v2(23.14,62.81) ; v2(18.46,58.14) 18.25,57.93 17.89,57.93 17.78,58.04 L6.4
  BOTTOM w0.097: v2(18.46,58.14) 18.71,57.88 19.27,57.88 21.7,60.32 21.7,60.61 23.41,62.32 23.41,62.54 v2(23.14,62.81)
USB_A0_USB2_U_P: length 9.8
  TOP w0.097: U37.10 23.64,62.38 23.56,62.46 23.56,62.61 v2(23.77,62.81) ; v2(18.43,57.55) 18.24,57.75 17.95,57.75 L6.1
  BOTTOM w0.097: v2(23.77,62.81) 23.6,62.64 23.6,62.24 21.89,60.53 21.89,60.24 19.35,57.7 18.58,57.7 v2(18.43,57.55)
USB_A1_CHARGE_EN_L: length 72.6
  TOP w0.079: U17.F7 v1(153.56,24.02)
  IN1 w0.097: v1(162.97,26.66) 162.98,26.66 164.46,26.66 164.65,26.85 166.58,26.85 167.96,25.46 168.93,25.46 v2(169.03,25.56)
  IN2 w0.079: v1(153.56,24.02) 153.79,24.02 153.91,23.9 156.23,23.9 156.78,24.44 156.78,26.26 157.17,26.66 158.06,26.66
  IN2 w0.097: v2(191.79,50.63) 191.65,50.63 190.35,49.34 190.35,29.65 184.22,23.52 177.78,23.52 174.77,20.51 173.92,20.51 172.95,21.48 169.99,21.48 169.42,22.05 169.42,24.03 169.03,24.42 v2(169.03,25.56) ; 158.06,26.66 158.56,26.66 158.9,26.99 159.58,26.99 160.22,27.62 162.71,27.62 162.98,27.34 162.98,26.67 162.98,26.66 v1(162.97,26.66)
  BOTTOM w0.114: v2(191.79,50.63) 191.81,50.63 192.83,51.65 J12.18
USB_A1_OC_ODL: length 186.3
  TOP w0.109: v2(88.37,54) 88.37,55.27 90.44,57.34 91.2,57.34 93.07,59.21 93.07,59.31 93.62,59.85 94.15,59.85 94.22,59.92 94.31,59.92 94.51,60.12 R91323.2
  IN2 w0.097: v2(106.98,21.31) 106.74,21.55 95.59,21.55 93.99,23.15 89.11,23.15 87.33,24.93 87.33,25.95 82.27,31.01 82.27,45.64 88.37,51.74 v2(88.37,54) ; v2(191.79,49.85) 190.75,48.8 190.75,29.44 184.4,23.09 177.92,23.09 174.91,20.08 173.51,20.08 173.22,20.37 171.23,20.37 170.49,19.63 169.84,19.63 167.12,16.91 162.77,16.91 158.22,12.37 112.71,12.37 v2(108.86,16.22)
  BOTTOM w0.114: J12.17 192.68,52.15 192.55,52.02 192.55,51.71 191.95,51.12 191.66,51.12 191.28,50.73 191.28,50.35 v2(191.79,49.85) ; v2(106.98,21.31) 108.11,21.31 108.67,20.75 108.67,16.41 v2(108.86,16.22)
USB_A1_SSRX_N: length 129.3
  TOP w0.089: v2(109.11,76.21) 108.73,75.83 108.73,75.42 108.52,75.22 108.52,73 U1JSL.BU2
  IN4 w0.097: v2(109.11,76.21) 109.11,76.08 109.34,75.86 109.78,75.86 111.33,74.31 118.46,74.31 119.09,74.94 129.61,74.94 130.21,74.34 134.31,74.34 140.17,80.21 166.17,80.21 168.27,78.11 168.27,74.35 169.84,72.78 181.97,72.78 192.47,62.27 192.47,48.65 191.81,47.99 191.81,35.53 191.94,35.4 192.08,35.4 v2(192.33,35.65)
  BOTTOM w0.097: J13.23 192.94,35.65 192.73,35.43 192.55,35.43 v2(192.33,35.65)
USB_A1_SSRX_P: length 129.3
  TOP w0.089: v2(109.11,75.55) 108.7,75.14 108.7,73.24 108.99,72.95 108.99,72.73 108.67,72.41 U1JSL.BU4
  IN4 w0.097: v2(192.33,35.05) 192.18,35.2 191.86,35.2 191.61,35.44 191.61,48.08 192.27,48.74 192.27,62.19 181.88,72.58 169.75,72.58 168.06,74.27 168.06,78.03 166.09,80.01 140.26,80.01 134.39,74.14 130.12,74.14 129.52,74.74 119.18,74.74 118.54,74.1 111.25,74.1 109.7,75.65 109.21,75.65 v2(109.11,75.55)
  BOTTOM w0.097: J13.24 192.92,35.15 192.82,35.25 192.53,35.25 v2(192.33,35.05)
USB_A1_SSTX_N: length 114.9
  TOP w0.089: U1JSL.BP12 110.29,68.52 110.37,68.44 110.37,68.29 110.27,68.19 v2(109.71,68.19)
  IN4 w0.097: v2(109.71,68.19) 109.71,68.39 109.81,68.48 109.97,68.48 110.17,68.28 110.17,67.42 110.58,67.02 112.12,67.02 112.65,66.48 115.12,66.48 115.15,66.51 131.39,66.51 131.75,66.86 134.08,66.86 134.36,67.14 139.53,67.14 140.48,66.19 143.31,66.19 144.16,67.04 161.52,67.04 162.41,67.93 177.73,67.93 189.31,56.35 189.31,52.51 190.28,51.55 190.28,35.12 190.1,34.94 189.96,34.94 v2(189.76,35.14)
  BOTTOM w0.097: v2(189.76,35.14) 189.97,34.93 191.16,34.93 192.09,33.99 192.77,33.99 192.93,34.15 J13.26
USB_A1_SSTX_P: length 114.9
  TOP w0.089: U1JSL.BP10 110.04,69.18 v2(109.71,68.85)
  IN4 w0.097: v2(109.71,68.85) 109.87,68.69 110.05,68.69 110.38,68.36 110.38,67.5 110.66,67.22 112.2,67.22 112.74,66.69 115.04,66.69 115.06,66.71 131.31,66.71 131.67,67.07 133.99,67.07 134.27,67.35 139.62,67.35 140.57,66.4 143.23,66.4 144.08,67.24 161.44,67.24 162.32,68.13 177.82,68.13 189.51,56.44 189.51,52.6 190.48,51.63 190.48,35.03 190.18,34.73 189.96,34.73 v2(189.76,34.53)
  BOTTOM w0.097: v2(189.76,34.53) 189.97,34.74 191.08,34.74 192.01,33.81 192.83,33.81 192.99,33.65 J13.27
USB_A1_STATUS_L: length 231.5
  TOP w0.109: R27308.1 26.4,57.13 26.51,57.03 27.42,57.03 27.94,56.51 29.51,56.51 v2(29.7,56.7)
  IN4 w0.089: v2(194.63,51.15) 195.03,50.75 195.03,50.32 194.63,49.92 194.63,24.75 189.58,19.7 182.44,19.7 178.04,15.3 167.79,15.3 164.21,11.73 110.36,11.73 109.68,12.41 107.76,12.41 107.23,11.87 95.29,11.87 94.25,12.91 85.59,12.91 84.85,13.65 84.85,15.65 84.46,16.05 78.2,16.05 77.46,15.31 70.9,15.31 70,16.22 70,17.27 66.44,20.82 66.44,22.43 66.43,22.44 66.43,26.97 59.89,33.51 53.39,33.51 44.32,42.59 39.02,42.59 37.8,43.82 37.8,44.85 34.03,48.61 34.03,53.05 31.53,55.55 30.77,55.55 29.7,56.62 v2(29.7,56.7)
  BOTTOM w0.114: J12.19 v2(194.63,51.15)
USB_A1_USB2_N: length 139.3
  TOP w0.089: U1JSL.CD1 105.76,73.33 105.76,73.55 105.69,73.62 105.69,74.97 105.3,75.36 105.3,76.18 105.43,76.3 105.59,76.3 105.68,76.21 v2(105.73,76.17)
  IN4 w0.097: v2(105.73,76.17) 105.73,76.08 105.49,75.84 105.33,75.84 105.05,76.13 105.05,76.72 105.67,77.35 110.4,77.35 111.56,76.19 124.47,76.19 126.07,77.79 128.8,77.79 130.57,79.56 131.81,79.56 132.38,79 135.18,79 137.49,81.3 167.97,81.3 171.23,78.04 171.23,75.82 171.98,75.06 181.27,75.06 193.54,62.79 193.54,32.8 193.12,32.38 192.92,32.38 192.82,32.48 192.82,32.98 192.75,33.05 192.56,33.05 192.33,32.82 v2(192.33,32.76)
  BOTTOM w0.097: J13.29 193,32.65 192.8,32.45 192.64,32.45 192.34,32.76 v2(192.33,32.76)
USB_A1_USB2_P: length 139.3
  TOP w0.089: U1JSL.CD3 105.78,72.52 105.78,72.97 105.94,73.13 105.94,73.63 105.86,73.7 105.86,75.05 105.73,75.18 v2(105.73,75.53)
  IN4 w0.097: v2(105.73,75.53) 105.62,75.64 105.25,75.64 104.84,76.05 104.84,76.81 105.59,77.55 110.48,77.55 111.65,76.39 124.38,76.39 125.98,77.99 128.71,77.99 130.49,79.77 131.89,79.77 132.46,79.2 135.1,79.2 137.4,81.5 168.05,81.5 171.43,78.13 171.43,75.9 172.07,75.27 181.35,75.27 193.74,62.88 193.74,32.72 193.2,32.18 v2(192.33,32.18)
  BOTTOM w0.097: J13.30 192.94,32.15 192.82,32.27 192.42,32.27 v2(192.33,32.18)
USB_C0_AUX_DC_N: length 1.9
  TOP w0.097: R210.2 C162.2 30.61,67.5 30.79,67.32 U6.20
USB_C0_AUX_DC_P: length 2
  TOP w0.097: U6.19 31.19,66.74 30.98,66.95 30.98,67.27 31.21,67.5 C161.2 R211.1
USB_C0_AUX_N: length 125.2
  TOP w0.089: U1JSL.K3 129.66,72.94 129.47,73.14 129.47,74.55 130.77,75.84 131.17,75.84 v2(131.34,76.01)
  TOP w0.097: v2(28.59,71.11) 28.54,71.05 Q13.1
  IN1 w0.097: v2(131.34,76.01) 131.5,75.84 132.14,75.84 132.21,75.77 134.11,75.77 134.4,76.05 134.4,78.01 133.42,78.99 133.18,78.99 131.12,81.05 123.34,81.05 120.21,84.18 111.29,84.18 110.24,83.14 94.52,83.14 94.05,82.66 87.32,82.66 84.96,80.3 75.46,80.3 70.71,75.55 70.71,74.79 68.02,72.11 37.9,72.11 36.89,71.09 33.04,71.09 32.4,70.46 29.75,70.46 29.42,70.79 29.42,70.99 29.3,71.11 v2(28.59,71.11)
USB_C0_AUX_P: length 125.2
  TOP w0.089: v2(131.34,75.41) 131.34,75.47 131.15,75.67 130.84,75.67 129.65,74.47 129.65,73.36 U1JSL.K1
  TOP w0.097: Q12.1 v2(30.9,71.1)
  IN1 w0.097: v2(131.34,75.41) 131.56,75.64 132.05,75.64 132.13,75.56 134.19,75.56 134.6,75.97 134.6,78.1 133.51,79.19 133.27,79.19 131.21,81.26 123.42,81.26 120.29,84.38 111.2,84.38 110.16,83.34 94.44,83.34 93.96,82.87 87.23,82.87 84.87,80.5 75.37,80.5 70.5,75.63 70.5,74.88 67.94,72.31 37.82,72.31 36.8,71.3 32.95,71.3 32.32,70.66 29.83,70.66 29.62,70.87 29.62,70.99 29.81,71.18 30.82,71.18 v2(30.9,71.1)
USB_C0_CC1: length 89.2
  TOP w0.203: U9.28 64.52,19.07 64.67,19.23 65.03,19.23 v2(65.47,18.78)
  IN4 w0.508: v2(32.33,68.49) 32.29,68.49 31.44,67.64 31.02,67.64 29.99,66.61 29.99,61.47 29.67,61.15 26.41,61.15 25.22,59.96 25.22,58.17 26.26,57.13 27.15,57.13 30.42,53.86 31.02,53.86 31.81,53.07 31.81,52.72 32.58,51.95 32.58,47.92 29.51,44.85 29.51,40.06 31.61,37.96 43.66,37.96 46.37,35.24 48.79,35.24 52.14,31.89 57.89,31.89 58.7,31.08 59.89,31.08 64.53,26.43 64.53,19.84 65.47,18.9 v2(65.47,18.78)
USB_C0_CC1_C: length 42.5
  TOP w0.254: J11.A5 6.8,74.6 v2(6.83,74.63)
  IN4 w0.508: v2(6.83,74.63) 6.83,74.6 6.66,74.43 6.66,71.92 7.46,71.12 9.1,71.12 10.21,72.24 12.86,72.24 13.58,71.51 13.58,69.58 15.22,67.94 15.88,67.94 19.5,64.32 23.22,64.32 29.31,70.42 32.72,70.42 34.92,68.22 v2(36.85,68.22)
USB_C0_CC2: length 86.4
  TOP w0.203: U9.29 64.39,19.47 64.53,19.62 64.91,19.62 v2(65.42,20.13)
  IN4 w0.508: v2(32.65,67.68) 31.73,66.76 31.39,66.76 30.8,66.18 30.8,61.03 30.09,60.32 26.75,60.32 26.04,59.61 26.04,58.59 26.61,58.02 27.42,58.02 30.69,54.75 31.37,54.75 32.82,53.3 32.82,52.87 33.42,52.27 33.42,47.59 30.32,44.49 30.32,40.44 31.98,38.78 44.23,38.78 46.88,36.13 49.29,36.13 52.72,32.7 58.33,32.7 59.14,31.89 60.24,31.89 65.42,26.71 v2(65.42,20.13)
USB_C0_CC2_C: length 47.1
  IN4 w0.508: v2(36.85,67.41) 34.56,67.41 32.36,69.61 29.67,69.61 23.53,63.46 19.2,63.46 15.52,67.13 14.79,67.13 12.77,69.15 12.77,71.16 12.5,71.42 10.57,71.42 9.46,70.31 8.48,70.31 7.09,68.92 3.57,68.92 3.08,69.41 3.08,72.34 3.79,73.05 J11.B5
USB_C0_CCSBU_OVP_ODL: length 175.6
  TOP w0.079: v1(155.62,28.56) 155.59,28.54 155.59,27.83 155.47,27.7 155.47,27.22 U17.J11
  TOP w0.109: v2(40.15,57.85) 39.98,58.02 39.98,59.71 v4(40.91,60.64) 40.91,63.42 40.67,63.66 40.67,66.39 40.3,66.77 39.85,66.77 39.64,66.98 U8.9
  IN4 w0.089: v1(155.62,28.56) 155.26,28.92 150.73,28.92 150.38,28.57 150.38,26.66 148.99,25.26 148.99,25.08 149.42,24.65 149.42,24.08 149.17,23.82 148.45,23.82 145.94,21.32 145.94,20.53 143.71,18.3 136.85,18.3 135.81,19.34 125.32,19.34 124.45,18.48 111.26,18.48 110.6,19.14 102.43,19.14 101.69,19.89 98.53,19.89 97.79,19.14 93.32,19.14 90.8,21.67 87.25,21.67 83.69,25.23 83.69,48.25 v2(82.92,49.02)
  BOTTOM w0.114: v2(82.92,49.02) 82.42,49.02 79.93,46.53 74.07,46.53 71.67,44.13 69.91,44.13 68.81,43.03 63.2,43.03 61.39,44.84 48.93,44.84 43.84,49.92 43.84,56.4 43.16,57.08 40.91,57.08 v2(40.15,57.85)
USB_C0_CHARGER_INT_ODL: length 23.4
  TOP w0.109: v2(64.81,18.73) 64.76,18.67 U9.27 ; v2(80.66,15.45) 80.59,15.38 D19.1 80.59,13.14 80.93,12.8 D29.1
  IN2 w0.097: v2(80.66,15.45) 80.27,15.85 78.19,15.85 77.44,16.6 70.19,16.6 69.61,16.03 66.15,16.03 65.69,16.48 65.16,16.48 64.28,17.36 64.28,18.2 v2(64.81,18.73)
USB_C0_IBUS_N: length 16.5
  TOP w0.203: U9.17 62.21,14.81 v2(62.2,14.79)
  TOP w0.305: R226.1 53.75,9.07 v2(53.75,8.6)
  IN4 w0.305: v2(62.2,14.79) 62.2,14.49 59.66,11.95 57.27,11.95 55.67,10.35 55.67,9.82 54.27,8.42 53.79,8.42 53.75,8.46 v2(53.75,8.6)
  BOTTOM w0.305: C1014.1 62.22,17.01 62.22,16.16 C189.2 62.2,15.54 v2(62.2,14.79)
USB_C0_IBUS_P: length 18.5
  TOP w0.203: U9.18 62.61,14.96 v2(62.78,14.79)
  TOP w0.305: R224.2 53.15,9.09 v2(53.15,8.6)
  IN4 w0.305: v2(53.15,8.6) 53.15,8.24 53.54,7.86 54.56,7.86 56.25,9.55 56.25,10.12 57.47,11.34 59.89,11.34 62.78,14.24 v2(62.78,14.79)
  BOTTOM w0.305: v2(62.78,14.79) 62.78,15.51 C189.1 62.78,16.16 62.78,17.01 C1013.1
USB_C0_INT_ODL: length 165.7
  TOP w0.079: U17.J2 155.19,20.82 155.47,20.54 155.47,20.31 155.36,20.21 155.36,19.83 v1(155.72,19.47)
  TOP w0.109: D19.2 v2(81.4,13.74)
  IN4 w0.089: v1(155.72,19.47) 153.84,17.59 149.72,17.59 146.94,14.81 144.07,14.81 143.76,14.5 111.17,14.5 110.21,15.45 103.14,15.45 102.72,15.03 95.68,15.03 95.34,15.36 92.19,15.36 91.42,16.14 91.42,18.31 89.73,20 83.01,20 81.8,18.79 79.45,18.79 v2(78.61,19.63) 78.61,20.09 76.41,22.29 74.05,22.29 72.27,24.07 72.27,26.82 73.26,27.81 73.26,36.43 71.78,37.91 71.78,40.97 70.27,42.48 62.64,42.48 62.13,42.99 51.28,42.99 44.11,50.16 41.57,50.16 35.25,56.49 35.25,57.72 v2(34.99,57.97)
  BOTTOM w0.114: v2(81.4,13.74) 81.4,15.8 78.61,18.6 v2(78.61,19.63) ; v2(34.99,57.97) 34.63,58.33 U7.5
USB_C0_ML0_N: length 118.7
  TOP w0.089: U1JSL.M2 129.09,72.68 129.21,72.56 129.31,72.56 129.38,72.63 129.38,72.97 129.27,73.08 129.27,74.64 130.66,76.03 130.66,76.78 130.74,76.86 130.89,76.86 131.03,76.72 v2(131.03,76.59)
  TOP w0.097: v2(34.5,61.15) 34.54,61.15 34.85,60.84 34.85,60.73 34.76,60.65 34.08,60.65 33.46,60.03 32.76,60.03 32.68,60.11 32.68,60.24 32.79,60.36 U6.40
  IN1 w0.097: v2(34.5,61.15) 34.88,60.77 35.2,60.77 35.4,60.56 36.42,60.56 37.32,61.47 37.32,62.32 37.85,62.85 43.76,62.85 46.57,65.67 46.57,66.42 47.45,67.3 49.34,67.3 51.43,69.38 52.41,69.38 52.58,69.21 66.47,69.21 66.92,69.66 68.98,69.66 73.35,74.03 73.35,74.77 74.35,75.78 75.38,75.78 77.42,77.82 86.4,77.82 88.75,80.17 95.24,80.17 95.8,80.74 111.27,80.74 112.26,81.72 118.86,81.72 122.84,77.74 129.02,77.74 129.85,76.92 130.71,76.92 v2(131.03,76.59)
USB_C0_ML0_P: length 118.7
  TOP w0.089: U1JSL.L4 128.8,72.7 128.8,72.98 129.09,73.28 129.09,74.72 130.48,76.1 130.48,76.85 130.66,77.04 130.89,77.04 v2(131.06,77.21)
  TOP w0.097: U6.39 32.39,60.37 32.49,60.27 32.49,60.04 32.69,59.84 33.53,59.84 34.16,60.46 34.84,60.46 35.03,60.65 35.03,61.07 v2(35.11,61.15)
  IN1 w0.097: v2(131.06,77.21) 130.97,77.12 129.93,77.12 129.11,77.94 122.92,77.94 118.94,81.93 112.17,81.93 111.19,80.94 95.72,80.94 95.15,80.38 88.66,80.38 86.31,78.03 77.34,78.03 75.3,75.98 74.27,75.98 73.14,74.86 73.14,74.11 68.89,69.86 66.84,69.86 66.39,69.41 52.66,69.41 52.49,69.58 51.34,69.58 49.26,67.5 47.36,67.5 46.37,66.5 46.37,65.75 43.67,63.05 37.77,63.05 37.11,62.4 37.11,61.55 36.33,60.77 35.49,60.77 v2(35.11,61.15)
USB_C0_ML1_N: length 118.4
  TOP w0.089: v2(132.56,76.74) 132.76,76.54 132.76,75.3 130.94,73.48 130.94,73.17 130.61,72.84 130.61,72.22 U1JSL.H4
  TOP w0.097: v2(34.5,62.29) 34.71,62.08 34.71,61.88 34.59,61.76 U6.3
  IN1 w0.097: v2(34.5,62.29) 34.69,62.1 34.69,61.81 34.94,61.56 36.07,61.56 36.56,62.04 36.56,62.89 37.12,63.46 43.35,63.46 44.98,65.09 44.98,65.69 47.19,67.91 49.04,67.91 51.4,70.27 68.74,70.27 72.69,74.22 72.69,74.96 74.12,76.39 75.13,76.39 77.18,78.45 86.16,78.45 88.51,80.8 94.95,80.8 95.49,81.34 111.02,81.34 112.04,82.36 119.24,82.36 122.79,78.8 129.23,78.8 130.06,77.98 131.04,77.98 131.94,77.07 132.23,77.07 v2(132.56,76.74)
USB_C0_ML1_P: length 118.4
  TOP w0.089: U1JSL.H3 130.89,72.86 131.11,73.09 131.11,73.4 132.94,75.23 132.94,76.95 v2(132.56,77.33)
  TOP w0.097: v2(35.11,62.29) 34.9,62.08 34.9,61.8 34.67,61.58 33.72,61.58 33.51,61.36 U6.2
  IN1 w0.097: v2(132.56,77.33) 132.5,77.28 132.02,77.28 131.12,78.18 130.14,78.18 129.32,79.01 122.88,79.01 119.32,82.56 111.96,82.56 110.94,81.54 95.41,81.54 94.87,81 88.42,81 86.07,78.65 77.1,78.65 75.05,76.6 74.04,76.6 72.48,75.05 72.48,74.3 68.65,70.47 51.32,70.47 48.96,68.11 47.11,68.11 44.78,65.78 44.78,65.18 43.27,63.66 37.04,63.66 36.35,62.98 36.35,62.12 35.99,61.76 35.03,61.76 34.89,61.89 34.89,62.08 v2(35.11,62.29)
USB_C0_ML2_N: length 117
  TOP w0.089: 131.89,77.62 131.91,77.61 131.91,77.6 132.15,77.36 132.15,76.49 131.97,76.31 131.97,75.25 130.24,73.52 U1JSL.J2
  TOP w0.097: 131.89,77.62 131.26,78.25 131.26,78.4 v2(131.46,78.6) ; U6.6 33.65,62.96 33.7,62.91 34.6,62.91 34.7,63.01 34.7,63.17 v2(34.48,63.39)
  IN1 w0.097: v2(34.48,63.39) 34.68,63.59 34.68,63.78 34.88,63.98 36.09,63.98 36.38,64.27 40.23,64.27 40.61,64.66 43.37,64.66 44.16,65.45 44.16,66.03 46.86,68.72 48.68,68.72 51.04,71.08 68.41,71.08 71.82,74.49 71.82,75.23 73.81,77.22 74.82,77.22 76.87,79.27 85.8,79.27 88.15,81.62 94.62,81.62 95.14,82.14 110.69,82.14 111.72,83.17 119.6,83.17 123.16,79.61 130.15,79.61 130.77,78.99 131.07,78.99 v2(131.46,78.6)
USB_C0_ML2_P: length 117
  TOP w0.089: U1JSL.J4 130.08,72.58 129.97,72.69 129.97,72.96 130.07,73.05 130.07,73.59 131.79,75.32 131.79,76.39 131.97,76.56 131.97,77.29 131.78,77.48 131.78,77.48 131.76,77.49
  TOP w0.097: 131.76,77.49 131.08,78.17 131.08,78.4 v2(130.88,78.6) ; U6.5 33.51,62.56 33.68,62.73 34.68,62.73 34.89,62.93 34.89,63.18 v2(35.08,63.37)
  IN1 w0.097: v2(35.08,63.37) 34.88,63.57 34.88,63.69 34.97,63.78 36.17,63.78 36.47,64.07 40.31,64.07 40.7,64.46 43.46,64.46 44.37,65.37 44.37,65.94 46.94,68.51 48.76,68.51 51.12,70.88 68.5,70.88 72.03,74.41 72.03,75.15 73.89,77.01 74.9,77.01 76.95,79.07 85.88,79.07 88.23,81.42 94.71,81.42 95.23,81.94 110.77,81.94 111.8,82.97 119.52,82.97 123.07,79.41 130.07,79.41 v2(130.88,78.6)
USB_C0_ML3_N: length 119.3
  TOP w0.089: v2(133.83,77.4) 133.83,77.35 133.57,77.1 133.42,77.1 133.19,76.87 133.19,75.09 131.58,73.48 131.58,73.36 131.49,73.27 U1JSL.G1
  TOP w0.097: v2(34.5,64.49) 34.7,64.29 34.7,64.15 34.6,64.05 33.76,64.05 33.65,64.16 U6.9
  IN1 w0.097: v2(133.83,77.4) 133.83,77.29 133.65,77.11 133.39,77.11 133.19,77.32 133.19,78.41 130.94,80.66 123.01,80.66 119.88,83.78 111.46,83.78 110.42,82.74 94.88,82.74 94.39,82.25 87.66,82.25 85.3,79.88 75.62,79.88 71.19,75.45 71.19,74.71 68.17,71.69 50.79,71.69 48.43,69.33 46.6,69.33 43.54,66.27 43.54,65.69 43.14,65.28 40.38,65.28 40.01,64.91 36.14,64.91 35.86,65.19 34.95,65.19 34.7,64.94 34.7,64.69 v2(34.5,64.49)
USB_C0_ML3_P: length 119.3
  TOP w0.089: U1JSL.F3 131.76,73.19 131.76,73.41 133.37,75.01 133.37,76.8 133.49,76.92 133.67,76.92 v2(133.83,76.77)
  TOP w0.097: U6.8 33.65,63.76 33.76,63.87 34.68,63.87 34.89,64.08 34.89,64.27 v2(35.11,64.49)
  IN1 w0.097: v2(133.83,76.77) 133.69,76.91 133.31,76.91 132.99,77.23 132.99,78.32 130.86,80.45 122.92,80.45 119.8,83.58 111.55,83.58 110.51,82.54 94.96,82.54 94.47,82.04 87.75,82.04 85.38,79.68 75.71,79.68 71.39,75.36 71.39,74.63 68.25,71.49 50.88,71.49 48.51,69.12 46.69,69.12 43.75,66.19 43.75,65.6 43.22,65.08 40.46,65.08 40.09,64.7 36.05,64.7 35.77,64.98 35.03,64.98 34.9,64.86 34.9,64.69 v2(35.11,64.49)
USB_C0_PSYS: length 1.9
  TOP w0.109: U9.10 59.21,14.71 59.33,14.6 R225.2
USB_C0_RST_ODL: length 2.3
  TOP w0.079: v1(155.51,25.32) U17.J9
  BOTTOM w0.114: TP87.1 153.99,25.92 154.91,25.92 v1(155.51,25.32)
USB_C0_RX1_C_N: length 10.1
  BOTTOM w0.097: C168.2 8.88,68.96 9.04,69.11 9.04,69.35 R220.1 8.8,69.72 9.04,69.95 9.04,70.15 5.99,73.21 5.99,74.82 4.97,75.83 4.43,75.83 J11.B10
USB_C0_RX1_C_P: length 10.1
  BOTTOM w0.097: J11.B11 4.28,76.02 5.05,76.02 6.17,74.9 6.17,73.28 9.22,70.23 9.22,69.84 9.36,69.71 R221.1 9.22,69.45 9.22,69.16 C169.2
USB_C0_RX1_L_N: length 5.1
  BOTTOM w0.097: L1.3 12.49,67.04 12.15,67.37 11.93,67.37 D8.2 D8.9 10.97,68.33 10.11,68.33 9.7,67.92 9.2,67.92 8.95,68.17 8.95,68.4 8.85,68.51 C168.1
USB_C0_RX1_L_P: length 5.1
  BOTTOM w0.097: C169.1 9.27,68.51 9.14,68.38 9.14,68.24 9.28,68.1 9.62,68.1 10.03,68.51 11.49,68.51 D8.10 D8.1 12.27,67.73 12.27,67.51 12.64,67.15 12.88,67.15 L1.2
USB_C0_RX1_U_N: length 19.9
  TOP w0.097: U6.24 29.56,64.96 29.48,64.88 28.45,64.88 28.25,64.68 28.25,64.32 v2(28.12,64.2)
  BOTTOM w0.097: L1.4 13.05,66.45 13.37,66.13 13.81,66.13 15.91,64.04 26.73,64.04 27.32,64.63 28.16,64.63 28.28,64.51 28.28,64.35 v2(28.12,64.2)
USB_C0_RX1_U_P: length 19.9
  TOP w0.097: U6.25 29.56,64.56 29.43,64.69 28.53,64.69 28.44,64.6 28.44,64.47 v2(28.72,64.18)
  BOTTOM w0.097: L1.1 13.18,66.58 13.45,66.32 13.89,66.32 15.98,64.22 26.65,64.22 27.24,64.81 28.24,64.81 28.46,64.59 28.46,64.45 28.72,64.2 v2(28.72,64.18)
USB_C0_RX2_C_N: length 3.9
  TOP w0.097: J11.A10 6.36,72.1 6.57,71.89 7,71.89 7.92,70.98 8.18,70.98 8.34,71.13 R222.1 8.56,70.94 8.89,70.94 9.03,71.08 C172.2
USB_C0_RX2_C_P: length 3.9
  TOP w0.097: J11.A11 6.43,71.6 6.54,71.71 6.93,71.71 7.84,70.79 8.1,70.79 8.33,70.57 R223.1 8.56,70.76 8.91,70.76 9.03,70.64 C173.2
USB_C0_RX2_L_N: length 6.5
  TOP w0.097: C172.1 9.48,71.12 9.65,70.94 9.83,70.94 10.08,70.7 10.08,70.15 10.47,69.76 11.87,69.76 12.24,70.13 12.46,70.13 12.62,70.29 D7.9 D7.2 13.74,70.29 13.9,70.13 14.15,70.13 14.24,70.04 14.41,70.04 L3.3
USB_C0_RX2_L_P: length 6.5
  TOP w0.097: C173.1 9.48,70.61 9.63,70.76 9.75,70.76 9.89,70.62 9.89,70.07 10.39,69.57 11.95,69.57 12.32,69.94 12.46,69.94 12.62,69.79 D7.10 D7.1 13.74,69.79 13.89,69.95 14.07,69.95 14.16,69.85 14.45,69.85 L3.2
USB_C0_RX2_U_N: length 20.6
  TOP w0.097: U6.33 29.97,61.36 29.87,61.25 27.74,61.25 24.96,64.03 19.22,64.03 16.27,66.98 16.27,69.47 15.69,70.06 15.22,70.06 L3.4
USB_C0_RX2_U_P: length 20.6
  TOP w0.097: U6.34 30.01,60.96 29.9,61.07 27.66,61.07 24.88,63.85 19.14,63.85 16.08,66.91 16.08,69.4 15.61,69.87 15.22,69.87 L3.1
USB_C0_SBU1_C: length 56.4
  TOP w0.097: R27289.1 34.57,70.03 34.73,69.87 34.93,69.87 v2(35.12,70.06) 35.31,69.87 35.54,69.87 35.63,69.97 R218.2 ; R216.2 43.85,69.98 43.99,69.85 44.23,69.85 v2(44.4,70.03) ; v2(7.26,73.29) 7.07,73.1 J11.A8
  IN1 w0.097: v2(7.26,73.29) 7.26,72.12 7.59,71.79 7.59,67.91 8.06,67.44 12.87,67.44 15.69,64.62 17.69,64.62 19.89,62.42 27.13,62.42 27.26,62.55 29.74,62.55 30.36,63.17 30.36,68.41 31.33,69.38 34.19,69.38 34.66,69.85 34.9,69.85 v2(35.12,70.06)
  IN4 w0.097: v2(44.4,70.03) 44.23,69.85 43.89,69.85 43.74,70 43.74,70.14 42.62,71.26 40.83,71.26 40.62,71.05 36.43,71.05 35.98,70.61 35.98,70.14 35.71,69.86 35.45,69.86 35.32,69.86 v2(35.12,70.06)
USB_C0_SBU1_U: length 23.8
  TOP w0.097: U6.22 29.97,65.76 29.76,65.98 28.51,65.98 28.36,65.83 28.36,65.73 v2(28.72,65.37) ; R214.1 41.98,69.95 41.89,69.86 41.72,69.86 v2(41.52,70.05) 41.36,69.89 U8.15
  IN1 w0.097: v2(28.72,65.37) 28.38,65.02 28.38,64.88 28.47,64.79 29.41,64.79 29.7,65.08 29.7,68.7 31.05,70.05 33.8,70.05 34.44,70.69 35.85,70.69 36.68,69.86 37.78,69.86 38.21,70.29 40.11,70.29 40.73,69.67 41.14,69.67 41.22,69.75 41.22,69.93 41.34,70.05 v2(41.52,70.05)
USB_C0_SBU2_C: length 60.3
  TOP w0.097: R217.2 43.85,69.51 44,69.66 44.17,69.66 v2(44.4,69.43) ; R219.2 35.63,69.61 35.55,69.69 35.34,69.69 v2(35.11,69.46) 34.89,69.69 34.7,69.69 34.57,69.56 R27288.1
  IN1 w0.097: v2(35.11,69.46) 34.93,69.65 34.74,69.65 34.27,69.18 31.41,69.18 30.56,68.32 30.56,63.08 29.82,62.34 27.34,62.34 27.22,62.22 19.8,62.22 17.61,64.41 15.61,64.41 12.78,67.23 7.98,67.23 7.29,67.93 4.72,67.93 3.13,69.52 3.13,73.73 J11.B8
  IN4 w0.097: v2(35.11,69.46) 35.32,69.66 35.45,69.66 35.79,69.66 36.19,70.06 36.19,70.53 36.51,70.85 40.71,70.85 40.91,71.05 42.54,71.05 43.54,70.06 43.54,69.92 43.81,69.65 44.19,69.65 v2(44.4,69.43)
USB_C0_SBU2_U: length 23.8
  TOP w0.097: R215.1 41.98,69.57 41.88,69.67 41.72,69.67 v2(41.52,69.47) 41.45,69.54 41.16,69.54 41.11,69.49 U8.14 ; v2(28.14,65.37) 28.17,65.4 28.17,65.91 28.43,66.16 U6.21
  IN1 w0.097: v2(28.14,65.37) 28.17,65.33 28.17,64.8 28.38,64.59 29.49,64.59 29.9,65 29.9,68.62 31.13,69.85 33.89,69.85 34.52,70.48 35.77,70.48 36.59,69.66 37.86,69.66 38.3,70.09 40.03,70.09 40.65,69.47 v2(41.52,69.47)
USB_C0_SSRX_N: length 94.6
  TOP w0.089: U1JSL.BY3 107.5,72.69 107.5,72.79 107.56,72.99 107.79,73.21 107.79,77.6 107.79,77.6 107.79,77.62
  TOP w0.097: U6.17 31.99,66.76 32.09,66.85 32.09,67.06 32.29,67.27 32.93,67.27 33.06,67.39 33.06,70.83 33.43,71.2 36.69,71.2 37.8,72.31 40.04,72.31 41.15,71.2 43.34,71.2 43.84,71.71 68.2,71.71 73.07,76.58 75.14,76.58 77.99,79.43 84.33,79.43 86.83,81.93 90.79,81.93 92.03,83.17 104.14,83.17 107.79,79.52 107.79,77.62
USB_C0_SSRX_P: length 94.6
  TOP w0.089: 107.6,77.62 107.6,77.6 107.61,77.6 107.61,74.61 107.51,74.51 107.29,74.51 107.2,74.41 107.2,74.34 107.31,74.23 107.52,74.23 107.61,74.15 107.61,74.04 107.51,73.94 107.29,73.94 107.2,73.84 107.2,73.69 107.28,73.61 107.52,73.61 107.61,73.52 107.61,73.28 107.53,73.2 107.46,73.2 U1JSL.BY1
  TOP w0.097: 107.6,77.62 107.6,79.44 104.06,82.98 92.1,82.98 90.87,81.75 86.91,81.75 84.41,79.24 78.07,79.24 75.21,76.39 73.15,76.39 68.28,71.52 43.92,71.52 43.41,71.02 41.07,71.02 39.96,72.13 37.88,72.13 36.77,71.02 33.51,71.02 33.24,70.75 33.24,67.31 32.89,66.97 32.75,66.97 32.63,67.08 32.36,67.08 32.27,66.99 32.27,66.87 32.39,66.75 U6.16
USB_C0_SSTX_N: length 87.7
  TOP w0.089: U1JSL.BU13 v2(108.57,68.19)
  TOP w0.097: U6.12 33.56,65.36 33.7,65.23 35.82,65.23 36.31,64.73 36.31,61.56 37.74,60.13 37.74,59.24 v2(37.99,58.99)
  IN1 w0.097: v2(37.99,58.99) 37.85,59.13 37.85,59.32 37.92,59.4 41.49,59.4 41.97,58.91 46.93,58.91 49.09,61.07 51.22,61.07 53.23,63.08 54.2,63.08 55.49,64.36 65.68,64.36 66.13,63.92 70.51,63.92 71.13,64.54 73.24,64.54 75.07,66.37 76.19,66.37 78.35,68.54 84.86,68.54 86.37,70.04 91.04,70.04 91.52,69.56 93.11,69.56 93.26,69.4 96.46,69.4 96.96,68.91 100.42,68.91 101.3,68.03 106.93,68.03 107.39,68.49 108.26,68.49 v2(108.57,68.19)
USB_C0_SSTX_P: length 87.7
  TOP w0.089: U1JSL.BU12 v2(108.57,68.85)
  TOP w0.097: v2(37.36,58.99) 37.55,59.19 37.55,60.06 36.13,61.48 36.13,64.65 35.74,65.04 33.73,65.04 33.65,64.96 U6.11
  IN1 w0.097: v2(108.57,68.85) 108.42,68.7 107.3,68.7 106.84,68.24 101.38,68.24 100.51,69.11 97.04,69.11 96.55,69.61 93.34,69.61 93.19,69.76 91.61,69.76 91.13,70.24 86.28,70.24 84.78,68.74 78.27,68.74 76.1,66.57 74.99,66.57 73.16,64.74 71.05,64.74 70.43,64.12 66.21,64.12 65.77,64.57 55.4,64.57 54.12,63.28 53.15,63.28 51.14,61.28 49.01,61.28 46.85,59.12 42.06,59.12 41.57,59.6 37.84,59.6 37.65,59.41 37.65,59.28 v2(37.36,58.99)
USB_C0_TX1_C_N: length 5.9
  TOP w0.097: C170.2 10.8,75.38 10.9,75.48 10.9,75.74 10.52,76.12 7.05,76.12 6.84,75.91 6.67,75.91 6.35,75.6 J11.A3
USB_C0_TX1_C_P: length 5.9
  TOP w0.097: J11.A2 6.76,76.1 6.98,76.31 10.6,76.31 11.09,75.82 11.09,75.59 C171.2
USB_C0_TX1_L_N: length 6.7
  TOP w0.097: C170.1 10.77,74.74 10.77,74.58 11.9,73.46 11.9,71.74 12.24,71.4 12.54,71.4 12.65,71.29 D7.7 D7.4 13.8,71.29 13.93,71.42 14.43,71.42 L2.2
USB_C0_TX1_L_P: length 6.7
  TOP w0.097: C171.1 11.05,74.93 10.96,74.84 10.96,74.66 12.08,73.53 12.08,71.82 12.32,71.58 12.48,71.58 12.69,71.79 D7.6 D7.5 13.78,71.79 13.96,71.61 14.35,71.61 L2.3
USB_C0_TX1_U_N: length 22.2
  TOP w0.097: v2(28.14,62.99) 28.36,63.22 28.36,63.46 28.58,63.68 29.92,63.68 30,63.76 U6.27 ; L2.1 15,71.34 15.13,71.47 15.29,71.47 v2(15.51,71.25)
  IN1 w0.097: v2(28.14,62.99) 28.33,63.18 28.33,63.41 28.18,63.56 26.22,63.56 25.41,64.37 19.52,64.37 16.86,67.03 16.86,70.5 15.91,71.44 15.71,71.44 v2(15.51,71.25)
USB_C0_TX1_U_P: length 22.2
  TOP w0.097: v2(28.72,62.99) 28.55,63.16 28.55,63.38 28.66,63.49 29.85,63.49 29.99,63.36 U6.28 ; v2(15.51,71.84) 15.32,71.65 15.13,71.65 15,71.78 L2.4
  IN1 w0.097: v2(28.72,62.99) 28.53,63.18 28.53,63.5 28.26,63.77 26.31,63.77 25.49,64.58 19.6,64.58 17.06,67.12 17.06,70.58 16,71.65 15.71,71.65 v2(15.51,71.84)
USB_C0_TX2_C_N: length 7.4
  BOTTOM w0.097: 8.01,68 7.67,68 7.46,68.21 7.46,69.31 7.68,69.53 7.68,70.53 6.26,71.94 4.36,71.94 J11.B3
USB_C0_TX2_C_P: length 7.4
  BOTTOM w0.097: C176.2 7.55,67.54 7.55,67.85 7.27,68.13 7.27,69.39 7.49,69.61 7.49,70.45 6.19,71.76 4.36,71.76 J11.B2
USB_C0_TX2_L_N: length 5
  BOTTOM w0.097: L4.2 11.68,65.99 11.11,66.55 D8.4 D8.7 10.45,67.44 10.2,67.44 10.12,67.52 9.39,67.52 9.05,67.18 8.42,67.18 8.33,67.27 C175.1
USB_C0_TX2_L_P: length 5
  BOTTOM w0.097: L4.3 11.55,65.86 11.04,66.37 10.81,66.37 D8.5 D8.6 10.13,67.05 10.13,67.25 10.04,67.33 9.47,67.33 9.12,66.99 8.34,66.99 8.22,67.11 7.76,67.11
USB_C0_TX2_U_N: length 21.4
  TOP w0.097: v2(28.15,61.75) 28.42,62.01 28.42,62.18 28.65,62.41 29.88,62.41 30.03,62.56 U6.30
  BOTTOM w0.097: L4.1 12.24,65.43 14.22,63.44 24.67,63.44 25.54,62.58 26.37,62.58 27.68,61.27 28.32,61.27 28.42,61.37 28.42,61.47 v2(28.15,61.75)
USB_C0_TX2_U_P: length 21.4
  TOP w0.097: v2(28.75,61.75) 28.6,61.89 28.6,62.1 28.73,62.23 29.98,62.23 30.04,62.16 U6.31
  BOTTOM w0.097: L4.4 12.1,65.3 14.14,63.26 24.6,63.26 25.46,62.39 26.29,62.39 27.61,61.08 28.4,61.08 28.61,61.29 28.61,61.61 v2(28.75,61.75)
USB_C0_USB2_L_N: length 14.9
  TOP w0.097: L5.2 10.64,71.97 10.74,72.07 10.74,73.57 10.6,73.72 10.41,73.72 10.29,73.6 10.29,73.39 10.18,73.27 9.17,73.27 8.91,73.54 D2741.1 8.41,73.54 8.22,73.72 8.06,73.72 v2(7.9,73.56) 7.71,73.75 6.65,73.75 6.5,73.6 J11.A7
  IN4 w0.097: J11.B7 5.12,74.25 6.75,75.88 8.14,75.88 8.93,75.09 8.93,73.86 8.64,73.56 v2(7.9,73.56)
USB_C0_USB2_L_P: length 14.9
  TOP w0.097: J11.A6 6.49,74.1 6.65,73.94 7.69,73.94 v2(7.9,74.15) 8.14,73.91 D2741.2 8.91,73.91 9.17,74.17 10.02,74.17 10.28,73.9 10.68,73.9 10.93,73.65 10.93,72.13 L5.3
  IN4 w0.097: v2(7.9,74.15) 7.96,74.21 8.14,74.21 8.27,74.08 8.27,73.84 8.34,73.77 8.55,73.77 8.73,73.95 8.73,75 8.06,75.68 6.84,75.68 4.75,73.59 J11.B6
USB_C0_USB2_N: length 94.6
  TOP w0.089: U1JSL.CF1 104.87,73.24 104.87,73 104.8,72.92 104.71,72.92 104.58,73.05 104.58,77.26 104.76,77.44 104.76,78.05 104.58,78.23 104.58,78.37 104.59,78.38 104.59,78.4
  TOP w0.097: v2(47.64,70.42) 47.59,70.42 47.32,70.15 47.32,69.94 47.52,69.74 49,69.74 49.79,70.53 68.71,70.53 73.55,75.37 75.59,75.37 78.47,78.25 85.01,78.25 87.5,80.75 91.27,80.75 92.51,81.98 103.4,81.98 104.76,80.62 104.76,79.99 104.59,79.81 104.59,78.4
  IN1 w0.097: v2(37.74,65.34) 37.51,65.57 37.51,65.67 37.56,65.72 41.5,65.72 42.03,66.25 42.03,66.53 43.69,68.18 44.85,68.18 46.43,69.77 47.21,69.77 47.43,69.98 47.43,70.2 v2(47.64,70.42)
  BOTTOM w0.097: v2(37.74,65.34) 37.51,65.11 37.51,62.04 35.98,60.51 33.02,60.51 32.9,60.4 32.9,60.27 33.03,60.14 U7.2
USB_C0_USB2_P: length 94.6
  TOP w0.089: 104.4,78.4 104.4,78.38 104.41,78.37 104.41,78.15 104.58,77.98 104.58,77.51 104.41,77.33 104.41,72.98 104.84,72.54 U1JSL.CF3
  TOP w0.097: v2(47.01,70.42) 47.14,70.29 47.14,69.87 47.44,69.56 49.08,69.56 49.87,70.35 68.79,70.35 73.63,75.19 75.67,75.19 78.55,78.07 85.09,78.07 87.58,80.56 91.34,80.56 92.58,81.8 103.32,81.8 104.58,80.54 104.58,80.06 104.4,79.89 104.4,78.4
  IN1 w0.097: v2(37.1,65.34) 37.31,65.54 37.31,65.75 37.48,65.92 41.42,65.92 41.83,66.33 41.83,66.61 43.6,68.39 44.76,68.39 46.35,69.97 47.13,69.97 47.22,70.07 47.22,70.2 v2(47.01,70.42)
  BOTTOM w0.097: U7.1 32.63,60.11 32.72,60.19 32.72,60.47 32.94,60.7 35.91,60.7 37.32,62.11 37.32,65.12 v2(37.1,65.34)
USB_C0_USB2_U_N: length 32
  TOP w0.097: L5.1 10.65,71.43 10.65,70.55 v2(10.52,70.42)
  IN4 w0.097: v2(10.52,70.42) 10.52,69.69 12.59,67.62 12.59,67.53 15.72,64.4 16.76,64.4 18.94,62.22 25.12,62.22 25.22,62.11 25.22,61.92 v2(25.1,61.8)
  BOTTOM w0.097: U7.7 33.03,56.89 33,56.86 33,56.59 32.8,56.39 32.35,56.39 31.39,57.36 30.64,57.36 29.92,58.07 29.21,58.07 28.89,58.39 28.89,59.05 27.72,60.22 26.22,60.22 25.21,61.23 25.21,61.68 v2(25.1,61.8)
USB_C0_USB2_U_P: length 32
  TOP w0.097: v2(11.12,70.42) 11.09,70.42 10.83,70.68 10.83,71.33 11.05,71.54 L5.4
  IN4 w0.097: v2(25.7,61.8) 25.63,61.8 25.43,62 25.43,62.19 25.2,62.42 19.03,62.42 16.84,64.6 15.8,64.6 12.79,67.61 12.79,67.7 10.72,69.77 10.72,70.08 11.07,70.42 v2(11.12,70.42)
  BOTTOM w0.097: v2(25.7,61.8) 25.4,61.5 25.4,61.3 26.3,60.41 27.8,60.41 29.08,59.13 29.08,58.47 29.29,58.26 30,58.26 30.71,57.54 31.46,57.54 32.43,56.58 32.72,56.58 32.82,56.67 32.82,56.77 32.63,56.95 U7.8
USB_C0_VBUS_SENSE: length 7
  TOP w0.203: U9.20 63.9,15.67
  TOP w0.254: R1016.2 68.97,14.79 C1035.1 68.02,15.39 67.51,14.88 65.61,14.88 64.82,15.67 63.9,15.67
USB_C0_VBUS_VIN_GATE: length 13.7
  TOP w0.203: U9.19 63.01,15.32 63.44,14.9 v3(63.49,14.9)
  TOP w0.508: v3(53.56,12.47) 53.51,12.47 R1011.1
  IN4 w0.762: v3(63.49,14.9) 63.49,15.29 63.01,15.77 59.69,15.77 56.39,12.47 v3(53.56,12.47)
USB_C0_VBUS_VIN_SRC: length 13.8
  TOP w0.203: U9.16 61.81,15.25 61.59,15.02 v4(61.59,14.79)
  TOP w0.508: v4(52.47,8.32) 52.27,8.12 R1002.1
  IN2 w0.508: v4(52.47,8.32) 52.47,8.75 52.91,9.19 54.48,9.19 58.71,13.42 60.33,13.42 61.59,14.68 v4(61.59,14.79)
USB_C0_VX1:
  vias: v4(57.32,19.49)
USB_C0_VX2: length 6
  TOP w0.203: 60.06,21.84 59.99,21.77 59.99,21.07 60.21,20.84 U9.39
  TOP w0.762: 58.95,25.65 59.42,25.65 v4(60.06,25.01) C198.1 60.06,21.84
USB_C1_AUX_N: length 36.3
  TOP w0.089: v2(136.01,70.88) 136.01,70.71 135.92,70.62 135.23,70.62 134.63,70.03 133.48,70.03 133.44,70.06 133.2,70.06 133.19,70.04 132.69,70.04 U1JSL.D8
  TOP w0.097: v2(162.58,69.07) 162.98,68.67 163.49,68.67 163.94,68.22 Q10.1
  IN1 w0.097: v2(136.01,70.88) 136.01,70 136.23,69.78 138.54,69.78 138.8,69.53 141.28,69.53 141.83,70.09 145.22,70.09 146.11,69.2 148.96,69.2 150.5,67.65 159.22,67.65 159.7,67.17 161.36,67.17 162.63,68.44 162.63,69.02 v2(162.58,69.07)
USB_C1_AUX_N_HDMI_DDC_SDA: length 64.6
  TOP w0.097: R149.2 163.69,69.63 Q10.3 163.9,69.6 164.1,69.4 164.1,69 164.01,68.9 163.84,68.9 163.64,69.1 v2(163.16,69.1)
  IN4 w0.097: v2(163.16,69.1) 163.46,69.1 163.53,69.17 163.53,69.32 163.63,69.42 163.84,69.42 163.95,69.31 163.95,68.95 164.1,68.8 178.17,68.8 190.19,56.78 190.19,52.88 191.17,51.9 191.17,30.77 191.31,30.63 191.98,30.63 v2(192.33,30.98)
  BOTTOM w0.097: v2(192.33,30.98) 192.51,30.8 192.62,30.8 192.97,31.15 J13.32
USB_C1_AUX_P: length 36.3
  TOP w0.089: U1JSL.B9 133.4,69.85 134.71,69.85 135.3,70.45 136.4,70.45 136.59,70.64 v2(136.59,70.88)
  TOP w0.097: Q9.1 161.75,68.16 161.85,68.06 162.04,68.06 162.44,68.46 162.44,68.63 161.98,69.09 v2(161.82,69.09)
  IN1 w0.097: v2(161.82,69.09) 161.82,68.94 161.94,68.82 162.28,68.82 162.43,68.68 162.43,68.52 161.27,67.37 159.78,67.37 159.3,67.85 150.59,67.85 149.04,69.4 146.2,69.4 145.31,70.29 141.75,70.29 141.19,69.73 138.88,69.73 138.63,69.99 136.31,69.99 136.21,70.08 136.21,70.5 v2(136.59,70.88)
USB_C1_AUX_P_HDMI_DDC_SCL: length 64.9
  TOP w0.097: v2(161.23,69.07) 161.25,69.09 Q9.3 161.99,70.55 R148.2
  IN4 w0.097: v2(192.33,30.39) 191.21,30.39 190.94,30.67 190.94,51.8 189.96,52.78 189.96,56.68 178.08,68.57 161.73,68.57 v2(161.23,69.07)
  BOTTOM w0.097: v2(192.33,30.39) 192.45,30.52 192.74,30.52 192.87,30.65 J13.33
USB_C1_ML0_N: length 85.8
  TOP w0.089: U1JSL.D11 132.74,68.66 132.86,68.54 132.99,68.54 133.09,68.64 133.09,68.74 133.24,68.9 133.48,68.9 133.63,68.74 135.99,68.74 136.63,69.39 137.4,69.39 137.71,69.7 138.55,69.7 139.05,70.2 139.05,70.8 139.14,70.89 v2(139.36,70.89)
  IN1 w0.097: v2(187.38,43.11) 186.99,42.72 185.04,42.72 183.72,44.04 183.72,48.41 183.48,48.64 183.48,52.4 184.27,53.19 184.27,55.88 169.44,70.71 162.02,70.71 159.78,68.46 150.85,68.46 149.71,69.61 149.71,69.95 148.94,70.72 145.76,70.72 145.33,71.16 140.98,71.16 140.17,70.34 139.53,70.34 139.24,70.64 139.24,70.77 v2(139.36,70.89)
  BOTTOM w0.097: J13.11 192.91,41.65 192.62,41.36 191.44,41.36 190.1,42.7 187.79,42.7 v2(187.38,43.11)
USB_C1_ML0_P: length 85.8
  TOP w0.089: v2(138.7,70.89) 138.87,70.72 138.87,70.27 138.48,69.88 137.63,69.88 137.32,69.57 136.56,69.57 135.91,68.92 133.71,68.92 133.55,69.07 133.17,69.07 133.09,69 132.59,69 132.18,68.58 U1JSL.E12
  IN1 w0.097: v2(187.38,42.52) 184.96,42.52 183.51,43.96 183.51,48.32 183.28,48.56 183.28,52.48 184.07,53.27 184.07,55.8 169.36,70.51 162.11,70.51 159.86,68.26 150.77,68.26 149.51,69.52 149.51,69.87 148.85,70.52 145.68,70.52 145.25,70.95 141.06,70.95 140.25,70.14 139.45,70.14 v2(138.7,70.89)
  BOTTOM w0.097: v2(187.38,42.52) 190.02,42.52 191.37,41.17 192.89,41.17 192.91,41.15 J13.12
USB_C1_ML1_N: length 84.7
  TOP w0.089: U1JSL.D10 132.47,69.18 132.87,69.58 133.08,69.58 133.17,69.49 133.43,69.49 133.61,69.67 135.12,69.67 135.46,70.01 137.17,70.01 137.31,70.15 v2(137.31,70.86)
  IN1 w0.097: v2(187.38,44.89) 187.28,44.79 186.38,44.79 186.05,44.46 185.1,44.46 184.41,45.15 184.41,48.71 184.18,48.93 184.18,51.8 185.04,52.67 185.04,55.95 169.69,71.31 161.76,71.31 159.52,69.07 151.1,69.07 150.39,69.78 150.39,70.42 149.47,71.33 146.17,71.33 145.69,71.82 140.78,71.82 140.45,71.49 139.63,71.49 139.61,71.51 137.77,71.51 137.5,71.25 137.5,71.05 v2(137.31,70.86)
  BOTTOM w0.097: J13.8 192.91,43.15 192.75,42.99 190.83,42.99 188.93,44.89 v2(187.38,44.89)
USB_C1_ML1_P: length 84.7
  TOP w0.089: U1JSL.C10 133.01,69.31 133.51,69.31 133.69,69.49 135.2,69.49 135.54,69.83 137.25,69.83 137.49,70.08 137.49,70.53 137.82,70.86 v2(138.05,70.86)
  IN1 w0.097: v2(138.05,70.86) 137.8,70.86 137.7,70.96 137.7,71.16 137.85,71.31 139.52,71.31 139.55,71.28 140.54,71.28 140.87,71.61 145.6,71.61 146.09,71.13 149.39,71.13 150.18,70.34 150.18,69.7 151.01,68.87 159.61,68.87 161.84,71.11 169.61,71.11 184.84,55.87 184.84,52.75 183.98,51.89 183.98,48.85 184.2,48.62 184.2,45.06 185.01,44.25 186.13,44.25 186.47,44.59 187.09,44.59 v2(187.38,44.3)
  BOTTOM w0.097: v2(187.38,44.3) 187.79,44.71 188.85,44.71 190.75,42.81 192.75,42.81 192.91,42.65 J13.9
USB_C1_ML2_N: length 83.9
  TOP w0.089: U1JSL.A7 133.95,71.02 134.48,71.02 135.21,71.75 136.73,71.75 136.8,71.82 136.8,71.97 v2(136.62,72.15)
  IN1 w0.097: v2(136.62,72.15) 136.54,72.15 136.29,72.4 136.29,72.87 136.63,73.21 138.7,73.21 138.98,72.93 146.22,72.93 146.8,72.35 151.37,72.35 152.71,71.01 159.86,71.01 161.73,72.88 167.99,72.88 168.55,72.32 170.34,72.32 186.98,55.68 186.98,46.04 186.7,45.76 186.17,45.76 v2(185.89,46.04)
  BOTTOM w0.097: J13.5 192.91,44.65 192.75,44.49 192.75,44.43 192.66,44.34 190.7,44.34 188.96,46.08 187.1,46.08 186.66,45.65 186.29,45.65 186.02,45.92 186.02,45.92 186.01,45.93 185.99,45.93 v2(185.89,46.04)
USB_C1_ML2_P: length 83.9
  TOP w0.089: U1JSL.B7 133.45,71.13 133.52,71.2 134.41,71.2 135.13,71.93 135.76,71.93 v2(135.98,72.15)
  IN1 w0.097: v2(135.98,72.15) 136.09,72.25 136.09,72.96 136.55,73.42 138.79,73.42 139.07,73.14 146.3,73.14 146.89,72.55 151.45,72.55 152.8,71.21 159.78,71.21 161.65,73.08 168.08,73.08 168.63,72.53 170.42,72.53 187.19,55.76 187.19,45.95 186.79,45.55 186.01,45.55 v2(185.89,45.44)
  BOTTOM w0.097: J13.6 190.63,44.15 188.88,45.9 187.17,45.9 186.74,45.46 185.91,45.46 v2(185.89,45.44)
USB_C1_ML3_N: length 80.8
  TOP w0.089: U1JSL.A8 133.83,70.34 133.91,70.43 134.58,70.43 135.47,71.32 137.44,71.32 137.88,71.76 137.88,72.21 138.06,72.38 138.11,72.38
  TOP w0.097: v2(138.29,72.56) 138.11,72.38
  IN1 w0.097: v2(185.9,47.33) 185.9,47.22 185.67,47 185.56,47 185.5,47.06 185.5,48.02 186.01,48.53 186.01,55.86 169.95,71.92 167.08,71.92 166.59,72.41 165.27,72.41 164.79,71.93 161.49,71.93 160.13,70.57 152.42,70.57 151.04,71.95 146.6,71.95 146.03,72.53 139.46,72.53 139.08,72.15 138.1,72.15 138.03,72.22 138.03,72.36 138.23,72.56 v2(138.29,72.56)
  BOTTOM w0.097: v2(185.9,47.33) 185.9,47.27 186.19,46.97 186.65,46.97 186.78,47.1 189.45,47.1 190.71,45.84 192.6,45.84 192.69,45.93 192.69,46.04 192.8,46.15 J13.2
USB_C1_ML3_P: length 80.8
  TOP w0.089: U1JSL.C8 133.4,70.6 133.87,70.6 133.87,70.6 134.5,70.6 135.4,71.5 137.37,71.5 137.71,71.84 v2(137.71,72.56)
  IN1 w0.097: v2(137.71,72.56) 137.83,72.44 137.83,72.13 138.02,71.94 139.17,71.94 139.55,72.32 145.94,72.32 146.52,71.75 150.96,71.75 152.34,70.37 160.22,70.37 161.58,71.73 164.87,71.73 165.35,72.21 166.5,72.21 167,71.72 169.87,71.72 185.81,55.78 185.81,48.61 185.3,48.11 185.3,46.97 185.48,46.8 185.78,46.8 v2(185.9,46.68)
  BOTTOM w0.097: v2(185.9,46.68) 186,46.78 186.73,46.78 186.86,46.91 189.38,46.91 190.64,45.65 J13.3
USB_C1_SSRX_N: length 127.4
  TOP w0.089: U1JSL.CA4 107.17,72.02 107.24,72.1 107.24,72.2 107.05,72.39 107.05,72.51 107.25,72.71 107.25,72.97 107.15,73.08 107.15,73.28 106.98,73.44 106.98,75.44 107.07,75.53 v2(107.2,75.53)
  IN4 w0.097: v2(107.2,75.53) 107.2,75.62 107.37,75.79 107.79,75.79 108.67,76.68 110.02,76.68 111.96,74.74 117.91,74.74 118.54,75.37 129.97,75.37 130.55,74.79 134.05,74.79 139.94,80.68 166.42,80.68 168.75,78.35 168.75,76.46 170.54,74.67 170.54,73.78 171.05,73.27 182.2,73.27 192.91,62.57 192.91,40.14 192.75,39.99 192.55,39.99 v2(192.38,40.15)
  BOTTOM w0.097: v2(192.38,40.15) 192.54,39.99 192.83,39.99 192.99,40.15 J13.14
USB_C1_SSRX_P: length 127.4
  TOP w0.089: v2(107.2,76.16) 106.81,75.77 106.81,73.37 106.97,73.21 U1JSL.CA2
  IN4 w0.097: v2(107.2,76.16) 107.37,76 107.7,76 108.59,76.88 110.1,76.88 112.04,74.94 117.82,74.94 118.46,75.58 130.05,75.58 130.64,74.99 133.96,74.99 139.85,80.88 166.51,80.88 168.95,78.43 168.95,76.54 170.74,74.75 170.74,73.87 171.13,73.48 182.29,73.48 193.11,62.66 193.11,40.06 192.84,39.79 192.6,39.79 v2(192.38,39.57)
  BOTTOM w0.097: J13.15 192.97,39.65 192.81,39.81 192.62,39.81 192.38,39.58 v2(192.38,39.57)
USB_C1_SSTX_N: length 113.2
  TOP w0.089: U1JSL.BU9 108.9,70.09 109.14,70.32 109.34,70.32 v2(109.62,70.04)
  IN4 w0.097: v2(189.72,38.73) 189.48,38.49 189.38,38.49 189.24,38.63 189.24,39.39 189.87,40.02 189.87,51.38 188.18,53.08 188.18,56.89 178.43,66.64 144.46,66.64 143.62,65.8 140.18,65.8 139.61,66.37 131.86,66.37 131.6,66.11 127.28,66.11 126.91,65.74 122.89,65.74 122.01,64.86 111.83,64.86 111.52,65.16 111.52,65.82 110.75,66.59 110.07,66.59 109.21,67.46 109.21,69.63 v2(109.62,70.04)
  BOTTOM w0.097: v2(189.72,38.73) 189.96,38.49 192.75,38.49 192.91,38.65 J13.17
USB_C1_SSTX_P: length 113.2
  TOP w0.089: U1JSL.BU8 108.9,70.48 v2(108.49,70.07)
  IN4 w0.097: v2(108.49,70.07) 108.91,70.07 109,69.97 109,67.38 109.99,66.39 110.67,66.39 111.32,65.74 111.32,65.08 111.74,64.65 122.1,64.65 122.98,65.53 126.99,65.53 127.37,65.91 131.68,65.91 131.94,66.17 139.53,66.17 140.1,65.59 143.71,65.59 144.54,66.43 178.34,66.43 187.97,56.8 187.97,52.99 189.67,51.3 189.67,40.11 189.03,39.47 189.03,38.55 189.29,38.29 189.58,38.29 v2(189.72,38.15)
  BOTTOM w0.097: v2(189.72,38.15) 189.88,38.31 192.75,38.31 192.91,38.15 J13.18
USB_C1_USB2_N: length 119.1
  TOP w0.089: U1JSL.CA8 107.1,70.29 106.94,70.13 106.71,70.13 v2(106.62,70.22)
  IN4 w0.097: v2(106.62,70.22) 106.42,70.42 106.31,70.42 106.24,70.35 106.24,67.96 107.38,66.81 108.99,66.81 110.91,64.89 110.91,63.59 111.13,63.37 122.09,63.37 123.83,65.11 127.39,65.11 127.42,65.08 131.46,65.08 132.13,65.75 139.09,65.75 139.68,65.16 144.1,65.16 144.97,66.03 177.99,66.03 187.56,56.46 187.56,52.82 189.24,51.14 189.24,40.32 188.59,39.67 188.59,37.16 189.17,36.57 189.38,36.57 189.52,36.71 189.52,36.78 v2(189.72,36.98)
  BOTTOM w0.097: v2(189.72,36.98) 190.14,36.56 191.7,36.56 192.01,36.86 192.62,36.86 192.91,37.15 J13.20
USB_C1_USB2_P: length 119.1
  TOP w0.089: U1JSL.CA6 107.03,71.16 106.7,70.83 v2(106.62,70.83)
  IN4 w0.097: v2(189.72,36.37) 189.09,36.37 188.38,37.07 188.38,39.76 189.03,40.41 189.03,51.05 187.35,52.73 187.35,56.37 177.9,65.82 145.05,65.82 144.19,64.96 139.59,64.96 139,65.55 132.21,65.55 131.54,64.88 127.33,64.88 127.3,64.91 123.92,64.91 122.18,63.17 111.05,63.17 110.71,63.5 110.71,64.81 108.91,66.61 107.3,66.61 106.03,67.88 106.03,70.43 106.22,70.62 106.42,70.62 v2(106.62,70.83)
  BOTTOM w0.097: J13.21 192.82,36.65 192.79,36.68 192.08,36.68 191.78,36.37 v2(189.72,36.37)
USER_PRES_ODL: length 3.2
  TOP w0.079: U13.A3 163.12,20.1 163.08,20.13 161.39,20.13 161.18,19.92
  TOP w0.109: 161.18,19.92 161.16,19.89 161.16,19.72 160.85,19.41 R73.2
VNN_VID: length 1.9
  TOP w0.254: R203.2 58.83,33.61 58.52,33.91 U33.13
WAKE_N: length 1.8
  TOP w0.089: v2(108.44,53.16) 108.6,53.16 U1JSL.BU47
  BOTTOM w0.114: v2(108.44,53.16) 108.63,52.97 v4(108.63,52.56)
  BOTTOM w0.117: R20.2 108.55,53.27 v2(108.44,53.16)
WCAM_RST_L: length 7.5
  TOP w0.089: v2(97.27,64.97) 97.3,64.97 97.87,65.55 99.51,65.55 99.57,65.49 100.39,65.49 100.52,65.62 100.82,65.62 100.94,65.56 101.07,65.56 101.5,65.65 U1JSL.CN18
  BOTTOM w0.114: v2(97.27,64.97) 96.65,65.6 95.38,65.6 95.06,65.92 TP127.1
