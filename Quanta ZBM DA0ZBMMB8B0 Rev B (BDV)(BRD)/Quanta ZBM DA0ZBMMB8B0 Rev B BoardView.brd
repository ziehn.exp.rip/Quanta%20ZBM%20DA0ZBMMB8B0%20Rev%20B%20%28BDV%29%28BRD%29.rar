# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Nets (continued)
PP3300_THRM: R91317.2 R91318.2 R91320.1
PP3300_THRM_R: C10711.1 R91320.2 U6581.5(VCC)
PP3300_TOUCH_S0: C96.1 J23.35 R325.1 R326.1 U35.3(OUT)
PP3300_TRACKPAD_A: C148.1 J18.6 R199.1 R252.2
PP3300_USB_C0_G: C163.1 C164.2 C165.1 C166.1 C167.1 C1002.1 C1003.1 C1004.1 C1005.1 C1006.1 C28006.1 R210.1 R398.2 U6.1 U6.4 U6.7(VDD_7) U6.10 U6.13 U6.23 U6.26 U6.29 U6.32 U7.12(VDD) U8.10(VPWR)
PP3300_WLAN_A: C102.2 C103.1 C104.1 C105.2 C106.2 C107.1 C108.1 C28007.1 C28008.2 C28009.1 R111.1 R112.2 R113.1 R116.1 R488.2 U16.5 U4100.4 U4100.5 U4100.72 U4100.73 U4100.A48 U4100.A49
PP3300A_EC_G: C114.1 C118.1 FB1.1 U17.D1
PP5000_CHARGER_INT: C200.1 R1004.2 U9.23
PP5000_CHARGER_INT_R: C202.1 R1004.1 U9.1
PP5000_IMVP9_PVCC: C231.1 R131.2 U10.29
PP5000_IMVP9_VCC: C27104.1 R27115.2 U10.10
PP5000_LSPK_U: C131.1 C135.2 R179.2 R91354.1 R91355.1 U2.23 U2.24
PP5000_RSPK_U: C139.1 C143.2 R186.2 R91356.1 R91357.1 U4.23 U4.24
PP5000_U: C98.1 C280.1 C363.1 R131.1 R179.1 R186.1 R267.2 R365.2 R431.2 R432.1 R447.1 R448.1 R450.1 R462.1 R1026.2 R27115.1 R27302.1 R27303.1 R27304.1 R27307.1 U22.12 U33.8 U37.1
PP5000_U_R: C258.2 C260.1 C262.1 C306.1 C307.1 C356.1 L16.2 R267.1 U31.10(VOUT)
PP5000_U_VCCIO_EXT: C362.1 R457.1 R462.2 U38.9(VCC)
PP5000_USB_A0_VBUS: C160.1 J10.1(VBUS) U37.12(VOUT)
PP5000_USB_C0_VCONN: C1012.1 R1026.1 U9.33
PPVAR_BAT: C244.1 C245.1 J14.7 J14.8 Q2.1 Q2.2 Q2.3(S3) U9.7
PPVAR_BL_PWR: F1.2 J23.31 J23.32 J23.33
PPVAR_KB_BL: C28024.1 CN2.3 CN2.4 D2747.1(CATHODE)
PPVAR_KB_BL_D: D2747.2 L27203.2 U5.C3
PPVAR_SYS: C199.1 C201.1 C203.1 C204.1 C213.1 C214.1 C215.1 C216.1 C217.1 C218.1 C219.1 C279.1 C281.1 C282.1 C283.1 C1016.1 C1018.1 C28025.1 F1.1 J13.39 J13.40 J13.41 J13.42 J13.43 J13.44 J13.45 J13.46 J13.47 J13.48 J13.49 J13.50 L27203.1 Q1008.2 R129.2 R228.2 R238.1 R258.1 R259.1 R272.1 R570.1 R1008.1 R1010.1 R1021.1 R91350.2 U9.21(VSYS) U19.2 U33.10 U33.11
PPVAR_SYS_1V1_DRAM: C226.1 C227.1 C398.1 Q34.2 R238.2 R441.2
PPVAR_SYS_IMVP9_VIN: C230.1 R129.1 U10.22
PPVAR_SYS_VCCIN_AUX: C372.1 R570.2 U21.20(VSYS)
PPVAR_USB_C0_VBUS: C181.1 C182.1 D25.1 J11.A4 J11.A9 J11.B4 J11.B9(VBUS#4) Q1000.5 R1016.1
PPVAR_USB_C0_VIN: C1036.1 Q1000.1 Q1000.2 Q1000.3(S3) R224.1 R1002.2 R27309.1 U18.1
PPVAR_USB_C0_VIN_R: C183.1 C188.1 C192.1 C193.1 C194.1 Q1001.2 R226.2 U18.2
PPVAR_VBAT_U: Q2.5 R229.1 U19.1
PPVAR_VCC_IN_SNS_N: R27121.1 U1JSL.J24 U10.13
PPVAR_VCC_IN_SNS_P: C405.1 R428.2 R27120.2 U1JSL.H24 U10.14
PPVAR_VCCIN: C1.1 C2.1 C3.1 C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C56.1 C58.1 C59.1 C178.1 C179.1 C180.1 C184.1 C185.1 C186.1 C190.2 C191.1 C195.2 C196.1 C276.1 C277.1 C278.1 C291.1 C292.1 C299.1 C318.1 C370.1 C371.1 C373.1 C374.1 C375.1 C376.1 C377.1 C502.1 C503.1 C504.1 C583.1 C587.1 C3205.1 C3208.1 C3210.1 C3213.1 C3216.1 C27218.1 C27220.1 L27202.2 R27120.1 R27223.1 U1JSL.A13 U1JSL.A18 U1JSL.B14 U1JSL.B17 U1JSL.B20 U1JSL.B22 U1JSL.C18 U1JSL.D14 U1JSL.D17 U1JSL.D20 U1JSL.D22 U1JSL.E14 U1JSL.E17 U1JSL.E19 U1JSL.E22 U1JSL.F14 U1JSL.F15 U1JSL.F17 U1JSL.F18 U1JSL.F19 U1JSL.F21 U1JSL.F22 U1JSL.H12 U1JSL.H14 U1JSL.H18 U1JSL.H22 U1JSL.J12 U1JSL.J14 U1JSL.J16 U1JSL.J18 U1JSL.J20 U1JSL.J22 U1JSL.L12 U1JSL.L14 U1JSL.L18 U1JSL.L22 U1JSL.L24 U1JSL.M12 U1JSL.M14 U1JSL.M16 U1JSL.M18 U1JSL.M20 U1JSL.M22 U1JSL.M24 U1JSL.P14 U1JSL.P18 U1JSL.P22 U1JSL.P24 U1JSL.R16 U1JSL.R18 U1JSL.R20 U1JSL.R22 U1JSL.R24 U1JSL.U17 U1JSL.U18
PPVAR_VCCIN_AUX: C32.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C174.1 C205.1 C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 C337.1 C339.1 C341.1 C343.1 C345.1 C350.1 C351.1 C3501.1 C3504.1 C3508.1 C3512.1 C3514.1 C3517.1 C3522.2 C3526.2 C3530.2 C3531.2 C3535.1 C3562.1 C3563.1 C3564.1 C28005.1 L12.2 R241.1 U1JSL.BD17 U1JSL.BD18 U1JSL.BD20 U1JSL.BE17 U1JSL.BE18 U1JSL.BE20 U1JSL.BG17 U1JSL.BG18 U1JSL.BG20 U1JSL.BJ17 U1JSL.BJ18 U1JSL.BJ20 U1JSL.BK17 U1JSL.BK18 U1JSL.BK20
PPVAR_VNNEXT: C286.1 C288.1 C406.2 L10.2 U1JSL.BP20 U1JSL.BT20 U1JSL.BU20 U1JSL.BW20 U1JSL.CA20 U33.16(VOUT1)
PROCHOT_ODL: R145.2 R363.2 R8603.2 R8606.2 R8609.2 R27113.1
PSYS: C155.2 C27101.2 R202.1 R225.1 R311.1 U10.9
PWR_BTN_ODL: Q16.2 Q22.3 R44.1 R99.2 R193.2 R284.1 SW1.1 SW1.3 U1.18
RAM_STRAP_0: R419.2 R420.1 U1JSL.CN13
RAM_STRAP_1: R417.2 R418.1 U1JSL.CR14
RAM_STRAP_2: R415.2 R416.1 U1JSL.CN11
RAM_STRAP_3: R413.2 R414.1 U1JSL.CH13
RAM_STRAP_4: R314.2 R341.1 U1JSL.CC26
RSMRST_PWRGD_L: D34.1(CATHODE) D36.2 R13.1 U17.B11
RSPK_LDO: C142.1 U4.19
RSPK_N: C28020.1 J4.1 R190.2
RSPK_P: C28019.1 J4.2 R189.2
RSPK_R_N: C146.2 R190.1 U4.22
RSPK_R_P: C145.2 R189.1 U4.27
RSPK_VCM: C141.1 U4.20(VCM)
RSVD_STRAP: R105.2 R107.1 U1JSL.CE26
RTC_RST_L: C3C8.1 Q20.3 R3C23.2 U1JSL.BP47
SD3_RCOMP: RT756.1 U1JSL.CM50
SD_CD_ODL: CR7.1 J9.9 R424.2 U1JSL.CE50
SD_CLK: CR2.1 J9.5 U1JSL.CF49
SD_CMD: R209.1 U1JSL.CG47
SD_CMD_R: CR3.1 J9.3 R209.2
SD_DATA0: R205.1 U1JSL.CJ47
SD_DATA0_R: CR1.1 J9.7 R205.2
SD_DATA1: R206.1 U1JSL.CJ50
SD_DATA1_R: CR6.1 J9.8 R206.2
SD_DATA2: R207.1 U1JSL.CG49
SD_DATA2_R: CR5.1 J9.1 R207.2
SD_DATA3: R208.1 U1JSL.CG51
SD_DATA3_R: CR4.1 J9.2 R208.2
SD_ILIM: R288.1 U34.2
SLP_S0_L: R39.1 U17.B6
SLP_S3_L: D33.1(CATHODE) D35.1(CATHODE) D39.1(CATHODE) D40.1(CATHODE) Q24.2 R18.1 R203.1 U17.K12
SLP_S4_L: D18.1(CATHODE) D1000.2 R19.1 R465.2 R1000.2 U17.A9
SLP_SUS_L: D26.3(COMMON ANODE) D27.1(CATHODE) D36.1(CATHODE) Q1010.2 R10.1 U17.G2 U32.4
SNDW_RCOMP: RT854.1 U1JSL.CR25
SRTC_RST_L: C3C9.1 Q21.3 R3C22.2 U1JSL.BR48
SUB_ANALOG: J13.34 Q23.1(S) R204.2 R284.2
SUB_USB_C1_INT_ODL: D30.1(CATHODE) J13.35 U17.E7
SYS_RST_ODL: C19.2 J15.6 R403.2 U1JSL.CF9 U13.C1 U17.H7
TEMP_SENSOR_1: C128.1 R320.2 R321.1 U17.F2
TEMP_SENSOR_2: C127.1 R322.2 R323.1 U17.E3
THRM_SET: R91321.1 R91322.1 U6581.1
TOUCH_INT_ODL: J23.38 U1JSL.CC19
TOUCH_RESET_L: J23.39 U1JSL.CE19
TOUCH_RPT_EN: J23.26 U1JSL.CN33
TP_1: TP41.1 U1JSL.BC13
TP_2: TP40.1 U1JSL.BC15
TP_3: TP43.1 U1JSL.CT49(TP_CT49)
TP_4: TP42.1 U1JSL.CR52
TP_IST_0: TP13.1 U1JSL.AW17
TP_IST_1: TP12.1 U1JSL.AY17
TP_PCH_IST_0: TP26.1 U1JSL.BK33
TP_PCH_IST_1: TP25.1 U1JSL.BG33
TP_RSVD_1: TP49.1 U1JSL.BP13
TP_RSVD_2: TP50.1 U1JSL.BP15
TP_RSVD_3: TP53.1 U1JSL.CC4
TP_RSVD_4: TP46.1 U1JSL.BJ15
TP_RSVD_5: TP47.1 U1JSL.BJ13
TP_RSVD_6: TP37.1 U1JSL.AW18
TP_RSVD_7: TP31.1 U1JSL.BP34
TP_RSVD_8: TP32.1 U1JSL.BM34
TP_RSVD_9: TP33.1 U1JSL.BT36
TP_RSVD_10: TP28.1 U1JSL.BU15
TP_RSVD_11: TP27.1 U1JSL.BW15
TP_RSVD_12: TP29.1 U1JSL.AU33
TP_RSVD_13: TP30.1 U1JSL.BT34
TP_RSVD_14: TP23.1 U1JSL.AK17
TP_RSVD_15: TP24.1 U1JSL.U33
TP_RSVD_16: TP15.1 U1JSL.AC17
TP_RSVD_17: TP14.1 U1JSL.AC18
TP_RSVD_18: TP16.1 U1JSL.AK33
TP_RSVD_19: TP18.1 U1JSL.U31
TP_RSVD_20: TP17.1 U1JSL.V31
TP_RSVD_21: TP20.1 U1JSL.AP33
TP_RSVD_22: TP19.1 U1JSL.AP34
TP_RSVD_23: TP22.1 U1JSL.V23
TP_RSVD_24: TP21.1 U1JSL.V25
TP_RSVD_25: TP52.1 U1JSL.AR1
TP_RSVD_26: TP51.1 U1JSL.BT38
TP_RSVD_28: TP35.1 U1JSL.A51
TP_RSVD_29: TP36.1 U1JSL.B52
TP_RSVD_30: TP44.1 U1JSL.BD33
TP_RSVD_31: TP45.1 U1JSL.BE33
TP_RSVD_32: TP54.1 U1JSL.AR17
TP_RSVD_33: TP48.1 U1JSL.CE40
TP_RSVD_34: TP38.1 U1JSL.BC10
TP_RSVD_35: TP39.1 U1JSL.BC12
TRACKPAD_INT_ODL: J18.2 R199.2 U1JSL.CR49
UART_AP_TX_DBG_RX: TP7.1 U1JSL.CH15 U13.E8
UART_C2D2_TX_EC_RX: R102.1 U1.16
UART_DBG_TX_AP_RX: R68.1 TP6.1 U1JSL.CF15
UART_DBG_TX_EC_RX: R102.2 R356.1 U17.K2
UART_DBG_TX_H1_RX: R67.1 U1.19 U13.H7
UART_EC_TX_DBG_RX: R315.1 U1.23 U17.H3
UART_EC_TX_H1_RX: R315.2 U13.J2
UART_H1_TX_AP_RX: R68.2 U13.G8
UART_H1_TX_DBG_RX: U1.20 U13.B9
UART_H1_TX_EC_RX: R356.2 U13.H4
UCAM_RST_L: TP113.1 U1JSL.CP18
USB2_BT_N: U1JSL.BW6 U4100.69
USB2_BT_P: U1JSL.BW8 U4100.70
USB2_ID: R595.1 U1JSL.CC6
USB2_RCOMP: R5F9.1 U1JSL.CC2
USB2_UFC_N: J23.10 U1JSL.BW12
USB2_UFC_P: J23.11 U1JSL.BW10
USB2_VBUSSENSE: R596.1 U1JSL.CC7
USB_A0_CHARGE_EN_L: Q38.2 U17.C1
USB_A0_ILIM_SEL: Q38.3 R27307.2 R27308.2 U37.4
USB_A0_OC_ODL: R27310.2 U37.13
USB_A0_SSRX_L_N: D5.5 D5.6(NC#4) J10.5 L7.2
USB_A0_SSRX_L_P: D5.4 D5.7 J10.6 L7.3
USB_A0_SSRX_N: L7.1 U1JSL.BV3
USB_A0_SSRX_P: L7.4 U1JSL.BV1
USB_A0_SSTX_C_N: C157.2 L8.1
USB_A0_SSTX_C_P: C156.2 L8.4
USB_A0_SSTX_L_N: D5.2 D5.9 J10.8 L8.2
USB_A0_SSTX_L_P: D5.1 D5.10 J10.9 L8.3
USB_A0_SSTX_N: C157.1 U1JSL.BP6
USB_A0_SSTX_P: C156.1 U1JSL.BP8
USB_A0_STATUS_L: J12.20 U37.9
USB_A0_USB2_L_N: D2742.2(K2) J10.2 L6.3
USB_A0_USB2_L_P: D2742.1 J10.3 L6.2
USB_A0_USB2_N: U1JSL.CE4 U37.2
USB_A0_USB2_P: U1JSL.CE2 U37.3
USB_A0_USB2_U_N: L6.4 U37.11
USB_A0_USB2_U_P: L6.1 U37.10
USB_A1_CHARGE_EN_L: J12.18 U17.F7
USB_A1_OC_ODL: J12.17 R91323.2
USB_A1_SSRX_N: J13.23 U1JSL.BU2
USB_A1_SSRX_P: J13.24 U1JSL.BU4
USB_A1_SSTX_N: J13.26 U1JSL.BP12
USB_A1_SSTX_P: J13.27 U1JSL.BP10
USB_A1_STATUS_L: J12.19 R27308.1
USB_A1_USB2_N: J13.29 U1JSL.CD1
USB_A1_USB2_P: J13.30 U1JSL.CD3
USB_C0_AUX_DC_N: C162.2 R210.2 U6.20
USB_C0_AUX_DC_P: C161.2 R211.1 U6.19
USB_C0_AUX_N: Q13.1(S) U1JSL.K3
USB_C0_AUX_P: Q12.1(S) U1JSL.K1
USB_C0_CC1: C252.1 D2746.1 R91340.2 U9.28
USB_C0_CC1_C: J11.A5 R91340.1 R91346.2 U8.4
USB_C0_CC2: C263.1 D2745.1 R91341.2 U9.29
USB_C0_CC2_C: J11.B5 R91341.1 R91345.2 U8.5
USB_C0_CCSBU_OVP_ODL: U8.9 U17.J11
USB_C0_CHARGER_INT_ODL: D19.1(CATHODE) D29.1(CATHODE) U9.27
USB_C0_IBUS_N: C189.2 C1014.1 R226.1 U9.17
USB_C0_IBUS_P: C189.1 C1013.1 R224.2 U9.18
USB_C0_INT_ODL: D19.2 U7.5 U17.J2
USB_C0_ML0_N: U1JSL.M2 U6.40
USB_C0_ML0_P: U1JSL.L4 U6.39
USB_C0_ML1_N: U1JSL.H4 U6.3
USB_C0_ML1_P: U1JSL.H3 U6.2
USB_C0_ML2_N: U1JSL.J2 U6.6
USB_C0_ML2_P: U1JSL.J4 U6.5
USB_C0_ML3_N: U1JSL.G1 U6.9
USB_C0_ML3_P: U1JSL.F3 U6.8
USB_C0_PSYS: R225.2 U9.10
USB_C0_RST_ODL: TP87.1 U17.J9
USB_C0_RX1_C_N: C168.2 J11.B10 R220.1
USB_C0_RX1_C_P: C169.2 J11.B11 R221.1
USB_C0_RX1_L_N: C168.1 D8.2 D8.9 L1.3
USB_C0_RX1_L_P: C169.1 D8.1 D8.10 L1.2
USB_C0_RX1_U_N: L1.4 U6.24
USB_C0_RX1_U_P: L1.1 U6.25
USB_C0_RX2_C_N: C172.2 J11.A10 R222.1
USB_C0_RX2_C_P: C173.2 J11.A11 R223.1
USB_C0_RX2_L_N: C172.1 D7.2 D7.9 L3.3
USB_C0_RX2_L_P: C173.1 D7.1 D7.10 L3.2
USB_C0_RX2_U_N: L3.4 U6.33
USB_C0_RX2_U_P: L3.1 U6.34
USB_C0_SBU1_C: J11.A8 R216.2 R218.2 R27289.1
USB_C0_SBU1_U: R214.1 U6.22 U8.15
USB_C0_SBU2_C: J11.B8 R217.2 R219.2 R27288.1
USB_C0_SBU2_U: R215.1 U6.21 U8.14
USB_C0_SSRX_N: U1JSL.BY3 U6.17
USB_C0_SSRX_P: U1JSL.BY1 U6.16
USB_C0_SSTX_N: U1JSL.BU13 U6.12
USB_C0_SSTX_P: U1JSL.BU12 U6.11
USB_C0_TX1_C_N: C170.2 J11.A3
USB_C0_TX1_C_P: C171.2 J11.A2
USB_C0_TX1_L_N: C170.1 D7.4 D7.7 L2.2
USB_C0_TX1_L_P: C171.1 D7.5 D7.6(NC#4) L2.3
USB_C0_TX1_U_N: L2.1 U6.27
USB_C0_TX1_U_P: L2.4 U6.28
USB_C0_TX2_C_N: C175.2 J11.B3
USB_C0_TX2_C_P: C176.2 J11.B2
USB_C0_TX2_L_N: C175.1 D8.4 D8.7 L4.2
USB_C0_TX2_L_P: C176.1 D8.5 D8.6(NC#4) L4.3
USB_C0_TX2_U_N: L4.1 U6.30
USB_C0_TX2_U_P: L4.4 U6.31
USB_C0_USB2_L_N: D2741.1 J11.A7 J11.B7 L5.2
USB_C0_USB2_L_P: D2741.2(K2) J11.A6 J11.B6 L5.3
USB_C0_USB2_N: U1JSL.CF1 U7.2
USB_C0_USB2_P: U1JSL.CF3 U7.1
USB_C0_USB2_U_N: L5.1 U7.7
USB_C0_USB2_U_P: L5.4 U7.8
USB_C0_VBUS_SENSE: C1035.1 R1016.2 U9.20
USB_C0_VBUS_VIN_GATE: R1011.1 U9.19
USB_C0_VBUS_VIN_SRC: R1002.1 U9.16
USB_C0_VX1: C197.1 L9.1 Q1001.9 U9.3
USB_C0_VX2: C198.1 L9.2 Q1008.9 U9.39
USB_C1_AUX_N: Q10.1(S) U1JSL.D8
USB_C1_AUX_N_HDMI_DDC_SDA: J13.32 Q10.3 R149.2
USB_C1_AUX_P: Q9.1(S) U1JSL.B9
USB_C1_AUX_P_HDMI_DDC_SCL: J13.33 Q9.3 R148.2
USB_C1_ML0_N: J13.11 U1JSL.D11
USB_C1_ML0_P: J13.12 U1JSL.E12
USB_C1_ML1_N: J13.8 U1JSL.D10
USB_C1_ML1_P: J13.9 U1JSL.C10
USB_C1_ML2_N: J13.5 U1JSL.A7
USB_C1_ML2_P: J13.6 U1JSL.B7
USB_C1_ML3_N: J13.2 U1JSL.A8
USB_C1_ML3_P: J13.3 U1JSL.C8
USB_C1_SSRX_N: J13.14 U1JSL.CA4
USB_C1_SSRX_P: J13.15 U1JSL.CA2
USB_C1_SSTX_N: J13.17 U1JSL.BU9
USB_C1_SSTX_P: J13.18 U1JSL.BU8
USB_C1_USB2_N: J13.20 U1JSL.CA8
USB_C1_USB2_P: J13.21 U1JSL.CA6
USER_PRES_ODL: R73.2 U13.A3
VNN_VID: R203.2 U33.13
WAKE_N: R20.2 U1JSL.BU47
WCAM_RST_L: TP127.1 U1JSL.CN18
WLAN_CLKREQ_ODL: R111.2 U1JSL.CL41 U4100.30
WLAN_DISABLE_L: R116.2 U1JSL.CH21 U4100.28
WLAN_INT_L: TP110.1 U4100.8
WLAN_PCIE_WAKE_ODL: R112.1 U1JSL.CE17 U4100.29
WLAN_PE_PLT_RST_L: R120.1 R27312.1 U16.4(Y) U4100.31
WLAN_PERST_L: R109.1 U1JSL.CJ17 U16.6
WLAN_REFCLK0: TP4.1 U4100.A44
WLAN_SCL: TP111.1 U4100.9
WLAN_SDA: TP112.1 U4100.10
WLAN_SUSCLK: R386.2 R387.2 R27311.2 U4100.A25
WLAN_SUSCLK_R: R386.1 U1JSL.BY49
WWAN_EN: TP101.1 U1JSL.CM33
WWAN_PERST: TP100.1 U1JSL.CN24
WWAN_RST_L: TP102.1 U1JSL.CC21
WWAN_SAR_DETECT_ODL: TP99.1 U1JSL.CR41
WWAN_WDISABLE_L: TP98.1 U1JSL.CH17
WWAN_WLAN_COEX1: R367.2 TP103.1
WWAN_WLAN_COEX2: R366.2 TP104.1
WWAN_WLAN_COEX3: R369.2 TP105.1
XTAL_PCH_38P4M_IN: C4102.1 R4102.2 U1JSL.BE1 Y4102.1
XTAL_PCH_38P4M_OUT: C4101.1 R4102.1 U1JSL.BE3 Y4102.3
XTAL_RTC_32K_IN: C4104.1 R4101.1 U1JSL.CE49 Y4101.2
XTAL_RTC_32K_OUT: C4103.1 R4101.2 U1JSL.CE48 Y4101.1
N17510052: D21.1(CATHODE) Q15.3
N17589030: C3609.1 R8.2
N17621727: D9.2 Q6.3
N17740383: R364.1 U10.25
N17740385: C234.2 R364.2
N17740537: R429.2 R430.1
N17740570: R268.1 R270.1
N17740572: R269.2 R270.2 R275.1
N17740737: C232.2 R362.2
N17740831: C305.2 R426.1 U10.15
N17740886: C305.1 C405.2 R426.2 R428.1 U10.16
N17740890: R135.2 R138.1
N17740892: R143.1 R232.1
N17740894: R235.2 R236.1
N17740896: R264.2 R265.1
N17742434: C125.1 C126.1 C388.1 C389.1 C390.1 C391.1 C392.1 C394.1 C27222.1 C27224.1 C27226.1 C27228.1 Q30.5 R1008.2
N17742859: C27230.1 R27221.2
N17743042: C360.1 C361.1 Q35.2 R1010.2
N17743283: R459.1 U38.5
N17743285: C364.1 R459.2
N17743387: R455.2 U38.4
N17743475: R458.1 U38.14
N17745848: C220.1 C221.1 C222.1 C223.1 C224.1 C321.1 C395.1 C396.1 C397.1 Q32.5 R1021.2
N17746077: R434.1 U21.11
N17746099: C319.1 R432.2 U21.15 U21.16
N17746131: R435.1 U21.10
N17746133: C320.1 R435.2
N17746351: C333.2 R442.1
N17746361: R436.1 U21.13
N17746433: U21.2 U21.3
N17746595: C322.2 R438.1
N17746603: C332.2 R440.1
N17746814: Q36.3 Q37.2 R466.2
N17746864: R244.1 U40.A1(VOUT)
N17747083: C284.2 L10.1 U33.1
N17747159: C284.1 U33.2
N17747309: C285.2 L11.1 U33.4
N17747334: R441.1 U22.9
N17747362: C285.1 U33.3
N17747473: R377.1 U22.18
N17747475: C366.1 R377.2
N17747804: R437.2 U22.13
N17747956: C1001.1 U22.4
N17749264: R345.1 U31.1
N17749266: C254.1 R345.2
N17749368: R319.2 R463.2 U31.6
N17749418: R263.1 U31.9
N17749420: C258.1 R263.2
N17749576: C265.1 C399.1 R272.2 U32.3(VIN)
N17749625: R347.1 U32.7
N17749627: C266.1 R347.2
N17749695: C353.1 R447.2 U32.2
N17750770: R346.1 U30.1
N17750772: C255.1 R346.2
N17750890: R464.2 U30.6
N17750944: R262.1 U30.12
N17750946: C257.1 R262.2
N17751357: C289.2 D28.2 R378.1
N17753294: R303.2 U36.3
N17753848: C296.1 U23.12
N17754636: R247.1 U24.A1 U24.B1(VOUT#2)
N17756404: C28022.2 C28023.2 D2744.1(CATHODE) Q14.2 R255.2 R257.1 R91343.2
N17788307: R380.2 U1JSL.CN27
N17788317: R381.2 U1JSL.CR33
N17788327: R382.2 R91323.1 U1JSL.CL30
N17788329: R383.2 R27310.1 U1JSL.CR27
N17801684: R331.2 U1JSL.CH30
N17801691: R332.2 U1JSL.CC28
N17813996: R333.2 U1JSL.CB30
N17814026: R334.2 U1JSL.CF30
N17814069: R385.2 U1JSL.CL14
N17814071: R335.2 U1JSL.CH23
N17814073: R336.2 U1JSL.CB28
N17814084: R337.2 U1JSL.CC30
N17817068: R369.1 U1JSL.CR22
N17817143: R366.1 U1JSL.CM22
N17817150: R367.1 U1JSL.CM20
N17996760: R91329.2 U2.14
N17996780: R91358.2 U2.10
N17997033: R91331.2 R91360.2 U2.8
N17997051: R91330.2 R91359.2 U2.9
N17997104: C137.1 U2.28
N17997107: C138.1 U2.21
N17998507: C145.1 U4.28
N17998525: C146.1 U4.21
N17999533: R91332.2 U4.14
N17999580: R91333.2 R91362.2 U4.9
N17999587: R91334.2 R91363.2 U4.8
N18000201: TP3.1 U3.4
N18000280: C82.2 U3.24
N18000283: C82.1 U3.21
N18000315: C83.1 U3.23
N18000324: C83.2 U3.22
N18000375: C79.1 U3.3
N18000412: C76.1 U3.13
N18000432: C73.1 U3.17
N18000455: C70.1 U3.25
N18000486: C69.1 U3.9(VREF2)
N18000635: C80.1 U3.26
N18002909: R91336.2 U3.27
N18002922: R91335.2 U3.28
N18004865: R88.1 U3.12
N18155934: R218.1 U8.1
N18155937: R219.1 U8.2
N18158439: R91345.1 R91348.2 U8.6
N18158454: R91346.1 R91347.2 U8.7
N18159921: C177.1 U8.3
N18182049: C161.1 Q12.3
N18182083: C162.1 Q13.3
N18863456: C1000.1 D1000.1(CATHODE) R1000.1 U40.B2
N19179626: C297.1 U23.10
N19267926: Q1000.4 R1011.2
N19268068: Q1001.1 U9.4
N19268072: Q1008.1 U9.38
N19268120: Q1001.8 U9.2
N19268132: Q1008.8 U9.40
N19268154: C197.2 R1006.1
N19268156: C198.2 R1007.2
N19268229: R1006.2 U9.5
N19268231: R1007.1 U9.37
N19268506: C1007.1 R1003.2
N19268516: C1009.1 R1005.2
N19268589: Q1009.3 R27309.2
N19268616: R1009.1 U9.15
N19268722: C1011.1 U9.26
N19268752: R363.1 U9.24
N19268837: R227.1 U9.11
N19280052: R27292.1 U17.M6
N19280076: C112.1 U17.A6
N19296116: TP114.1 U17.H5
N19296675: TP86.1 U17.M5
N19296851: Q23.3 R286.2
N19296894: R27291.1 U17.H4
N19413580: R27302.2 U37.6
N19413585: R27303.2 U37.7
N19413590: R27304.2 U37.8
N19413661: R27305.1 U37.16
N19413668: R27306.1 U37.15
N19634590: J12.14 R91349.2
N19680857: J12.2 R91325.2
N19699399: J12.3 R91324.2
N19966883: TP122.1 U4100.42
N19966886: TP123.1 U4100.43
N20128078: R313.1 U42.4(Y)
N20313359: Q1002.2 Q1010.3 R91337.2
N20313437: Q1002.3 R91338.2
N20647936: R91342.1 U1JSL.CE13
N21257964: R91354.2 U2.6
N21258000: R91355.2 U2.5
N21258275: R91356.2 U4.6
N21258324: R91357.2 U4.5
N21259361: R91361.2 U4.10
N21276426: DS1.5 R196.1
N21276500: DS1.1 R195.1
N21276510: DS1.3 R194.1

Pads without a net: HOLE1 1; HOLE2 1; J12 5 6 7 8 9; J15 18 20 22 24 26 28 30 32 34 44 46 54 56; J17 6 7 10 29 30; J18 1; J23 8 30 34; J24 2; J25 6 7 10 29 30; NOREF#2 1; NOREF#3 1; NOREF#5 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; NOREF#14 1; NOREF#15 1; U1 24; U1JSL A47 AB8 AB9 AB12 AB13 AD8 AD9 AD12 AD13 AG6 AG8 AG10 AG12 AJ8 AJ9 AM8 AM9 AM10 AM12 AM17 AM48 AN47 AN49 AP17 AP39 AP42 AP44 AP45 AP48 AR6 AR8 AR10 AR12 AT4 AT48 AU12 AU13 AU17 AW10 AW12 AY18 AY20 AY21 AY44 B3 B36 BA12 BA13 BA48 BB34 BB41 BB42 BB45 BC6 BC8 BD34 BF6 BF8 BF10 BF12 BJ2 BJ4 BJ6 BJ8 BJ10 BJ12 BK1 BK3 BL2 BL4 BL12 BL13 BN2 BN4 BP1 BP3 BV42 BV44 BV45 BY38 C37 C43 C45 CA10 CA12 CA13 CA15 CB23 CB24 CC23 CC38 CE23 CE28 CE32 CE36 CF19 CF32 CF34 CF38 CG3 CG4 CG48 CH2 CH3 CH32 CH36 CH38 CJ13 CJ26 CJ30 CK5 CL1 CL6 CL12 CL28 CM3 CM7 CM9 CM27 CM45 CN30 CN38 CN39 CN43 CN52 CP3 CP8 CP23 CP46 CR30 CR43 CR44 CT2 CT7 CT47 D3 D36 D47 E1 E41 E43 E50 F36 G42 J49 U15 U28 U30 W2 W6 W8 W12 W15; U2 1 2 3 31 32; U3 36 37; U4 1 2 3 31 32; U5 B2; U7 6; U8 19 20; U9 14; U10 1 30 31 32; U13 C3 C4 C5 C7 D7 E3 E7 F3 F7 G3 G5 G6 G7 H2 H3; U14 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U15 2 3 9 10 11; U17 C12 D11 E5 F4 F5 F6 G6 G11 J8 L2 L6 L7; U24 C1; U26 C1; U30 3; U31 3; U34 3; U36 4; U41 1; U4100 1 2 3 7 11 12 13 14 15 16 18 19 21 22 24 25 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 64 65 66 67 A8 A9 A10 A11 A12 A13 A14 A16 A17 A18 A27 A28 A29 A30 A45 A46 A47; U4301 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; U4401 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; U4601 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; U4701 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 1302 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 1955 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 563 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 637 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0V6_DRAM_EN: length 2
  TOP w0.203: R295.1 v4(184.63,39.94) 184.33,39.94 184,40.27 U22.7
0V6_DRAM_SNS: length 3.4
  TOP w0.109: U22.2 181.43,38.54 181.24,38.36 181.24,37.7 181.29,37.65 R443.2 181.29,37.28 181.57,36.99 181.57,36.75 R444.1 v4(180.76,36.6)
1V1_DRAM_EN: length 2.4
  TOP w0.203: U22.8 184.14,40.67 184.37,40.44 184.98,40.44 185.42,40 R239.1
1V1_DRAM_FB: length 4.5
  TOP w0.109: U22.6 183.43,39.47 183.32,39.37 R445.2 C380.2 183.32,36.33 ; 183.32,36.33 R446.1 ; 183.32,36.33 183.58,36.59 v4(184.04,36.59)
1V1_DRAM_LGATE: length 8.3
  IN2 w1.016: 172.1,45.02 172.36,44.77 175.28,44.77 176.42,43.62 179.85,43.62
  vias: v2(171.41,45.42) v2(171.41,44.78) v2(180.56,43.77) v2(180.56,43.08) v4(179.9,43.77)
1V1_DRAM_SW:
  vias: v4(178.45,43.88)
1V1_DRAM_UGATE: length 10.2
  TOP w0.203: U22.17 179.65,41.07 179.48,41.24 v2(179.11,41.24)
  IN2 w0.635: v2(179.11,41.24) 178.66,41.69 174.01,41.69 v2(171.37,39.05)
1V8_FB: length 2.6
  TOP w0.254: U32.5 72.66,23.94 72.99,23.61 R278.1 R277.2 C268.2
1V8_SW:
  vias: v4(75.05,29.55)
1V8_VCC: length 1.5
  TOP w0.254: U32.6 76.99,24.43 C267.1
3V3_IN:
  vias: v4(45.38,43.67)
3V3_LDO3: length 76.1
  TOP w0.203: U30.11 38.96,43.9 38.73,44.12 38.73,44.78 C358.1
  TOP w0.254: R91318.1 96.21,23.38 95.87,23.72 87.21,23.72 86.93,23.45 v2(86.93,23.42) ; v2(39.59,44.75) 39.58,44.75 39.58,45.21 39.43,45.36 C358.1
  IN2 w0.254: v2(86.93,23.42) 86.51,23.85 84.06,23.85 81.73,21.51 71.93,21.51 63.63,29.82 63.63,30.21 60.53,33.31 53,33.31 49.98,36.32 49.98,43.46 47.8,45.64 40.48,45.64 v2(39.59,44.75)
3V3_VCC: length 2
  TOP w0.203: C248.1 40.05,44.89 40.05,44.55 39.86,44.36 U30.9
5V_IN:
  vias: v4(44.57,36.31)
5V_LDO5: length 1.9
  TOP w0.203: C354.1 38.95,34.98 39.2,34.73 U31.12
5V_VCC: length 2.2
  TOP w0.203: U31.11 39.65,35.22 v4(39.45,35.42) 39.46,35.42 40.09,36.05 C256.1
AGND_HP: length 6.9
  TOP w0.203: v2(17.37,41.11) 17.54,40.94 U3.11 ; R91339.2 10.81,35.05 ; v2(16.58,37.27) 16.77,37.27 16.93,37.42 U3.19 ; R87.2 6.11,35.02
  TOP w0.381: C69.2 17.67,44.76 v2(17.79,44.87)
  TOP w0.508: C70.2 19.58,32.52 v2(19.63,32.47)
  BOTTOM w0.203: v2(17.37,41.11) 17.09,40.83 R184.2 ; R185.2 16.25,36.93 v2(16.58,37.27)
  BOTTOM w0.381: C73.2 17.09,37.77 v2(16.58,37.27)
  vias: v2(15.01,43.06) v2(15.01,42.48) v2(15.51,33.36) v2(20.34,46.16) v2(24.45,43.04) v2(25.04,43.06) v2(25.06,44.97) v3(5.89,46.07) v3(9.5,46.04) v3(13.12,36.7) v3(13.42,43.46) v3(13.42,41.65) v3(13.42,39.75) v3(13.89,44.89) v3(13.89,38.12) v4(4,35.09) v4(4.55,36.32) v4(7.38,36.09) v4(10.13,36.08)
GND: length 1322.8
  TOP w0.079: U13.G2 166.75,19.34 166.75,18.63 v1(166.86,18.53)
  TOP w0.081: 69.21,49.69 69.21,48.69 U14.N2 68.71,48.69 68.71,49.26 v2(69.17,49.73) 69.21,49.69
  TOP w0.088: U1JSL.A29 U1JSL.C29 ; U1JSL.C50 133.03,51.04 133.03,50.47 133.74,49.76 134.19,49.76 134.33,49.62 135.17,49.62 v1(135.18,49.61) 134.76,49.19 134.38,49.19 134.19,49.38 133.82,49.38 132.71,50.49 U1JSL.D52 ; v1(129.61,48.84) 129.61,49.45 129.32,49.74 129.32,49.93 129.15,50.1 129.15,50.64 U1JSL.M52 ; U1JSL.A40 U1JSL.C40 ; U1JSL.A27 133.85,61.95 134.88,61.95 135.26,61.56 v1(135.4,61.56) ; U1JSL.AJ52 121.38,50.56 121.38,50.07 121.51,49.94 121.51,49.45 v1(121.28,49.22) ; v1(137.31,52.76) 136.78,52.76 135.88,53.66 135.88,54.29 134.89,55.28 133.61,55.28 133.41,55.13 133.25,55.13 133.1,55.21 133.09,55.21 133.08,55.21 U1JSL.D41 ; v1(138.14,58.59) 137.31,58.59 137.18,58.59 136.21,59.56 133.88,59.56 U1JSL.A32 ; U1JSL.BE52 114.06,50.13 114.33,49.87 114.33,49.54 v1(113.95,49.17) ; U1JSL.BK52 111.65,50.31 111.26,49.92 111.26,49.86 ; U1JSL.AF52 U1JSL.AF50 ; U1JSL.AY52 116.48,50.09 116.73,49.84 116.73,49.57 v1(116.32,49.16) ; U1JSL.R52 U1JSL.R50 ; U1JSL.J52 130.25,50.06 130.5,49.81 130.5,49.5 130.71,49.29 v1(131.18,49.29) ; 134.98,51.65 134.48,52.15 133.97,52.15 U1JSL.A48 ; U1JSL.AL52 U1JSL.AL50 ; U1JSL.AU52 U1JSL.AU50 ; v1(115.45,52.1) U1JSL.BB50 U1JSL.BB52 ; U1JSL.AA52 U1JSL.AA50 ; U1JSL.A34 U1JSL.C34
  TOP w0.089: v1(110.62,52.1) U1JSL.BN50 U1JSL.BN52 ; U1JSL.CT15 U1JSL.CP15 ; v2(108.21,52.1) U1JSL.BV50 U1JSL.BV52 ; v1(113.03,52.1) 113.04,52.1 U1JSL.BG50 U1JSL.BG52 ; U1JSL.CT37 U1JSL.CP37 ; U1JSL.CC52 U1JSL.CC50 ; v1(127.79,60.68) U1JSL.R30 ; U1JSL.CT21 U1JSL.CP21
  TOP w0.102: U1JSL.CT32 U1JSL.CP32
  TOP w0.109: D17.5 128.64,20.58 ; D3.5 139.73,20.68 ; D16.5 126.47,20.58 ; D2.5 135.81,20.58 ; D4.5 142.51,20.68 ; D1.5 132,20.58
  TOP w0.13: 111.26,49.86 111.26,48.88 111.02,48.64 v1(111.02,48.29)
  TOP w0.15: U1JSL.CC50 105.79,52 v1(105.43,52.36) ; v1(109.02,49.66) 109.23,49.88 U1JSL.BT52 ; U1JSL.AW47 116.72,52.77 117.48,53.53 v1(117.48,53.97) ; U1JSL.C40 132.37,56.06 v1(132.36,56.07) ; v1(132.36,60.9) 132.37,60.89 U1JSL.C29 ; v1(112.97,53.3) 112.42,53.3 112.14,53.02 112.14,52.91 U1JSL.BK47 ; U1JSL.BT3 109.22,72.56 109.22,73.15 U1JSL.BT1 ; v1(127.64,52.1) U1JSL.R50 ; v1(132.13,52.73) 132.07,52.79 U1JSL.F47 ; v1(122.69,52.1) U1JSL.AF50 ; U1JSL.CA52 106.82,50.03 v2(106.75,49.97) ; v1(125.11,52.1) U1JSL.AA50 ; v2(101.66,66.94) U1JSL.CP15 ; v1(132.36,58.48) 132.37,58.48 U1JSL.C34 ; v2(101.66,64.53) U1JSL.CP21 ; v1(123.74,49.83) 123.72,49.84 U1JSL.AD52 ; v1(117.86,52.1) U1JSL.AU50 ; v1(120.28,52.1) U1JSL.AL50
  TOP w0.152: U1JSL.AN1 v2(119.31,74.33) ; R319.1 v2(43.88,35.42)
  TOP w0.178: v2(41.62,68.87) 41.45,68.87 41.23,69.09 U8.13 ; v2(34.56,65.75) 34.15,66.16 U6.14 ; v2(109.11,74.97) 109.11,74.94 109.1,74.93 U1JSL.BT1 ; U14.C4 67.46,43.94 v2(67.45,43.94) ; U1JSL.L6 U1JSL.L7 U1JSL.L8 v2(129.77,69.81) ; U6.15 34.49,66.49 35.16,65.82 v2(35.16,65.75) ; v2(31.39,68.41) 31.77,68.41 31.97,68.21 R211.2 ; v2(124.66,74.33) 124.41,74.09 U1JSL.AB1 ; U1JSL.P1 127.82,74.2 v2(127.94,74.33) ; v2(112.5,71.66) U1JSL.BJ3 U1JSL.BJ1 ; 39.64,71.56 40.04,71.16 U8.16 ; 39.64,71.56 U8.17 ; 39.64,71.56 v2(39.64,71.56) ; v2(39.88,65.32) 39.24,65.97 U8.8 ; v2(117.75,73.72) 117.6,73.58 U1JSL.AU1 U1JSL.AU3 ; v2(29.51,59.73) 29.89,60.11 30.45,60.11 30.79,60.45 U6.35 ; v2(113.87,73.72) 113.9,73.7 113.9,72.97 U1JSL.BF2 ; U1JSL.BM1 110.8,73.71 v2(110.79,73.72) ; U8.18 39.24,71.31 v2(38.99,71.55)
  TOP w0.18: U1JSL.A23 133.78,63.35 133,63.35 U1JSL.C23 ; U1JSL.V52 126.14,49.95 126.37,49.71 v1(126.37,49.7) ; v1(119.23,48.78) 119.23,50.34 118.94,50.64 U1JSL.AP52 ; U1JSL.BM1 U1JSL.BM3 110.77,72.41 110.77,71.93 ; U1JSL.L20 v2(129.11,64.47) ; U1JSL.H20 v2(130.43,64.47) ; v2(127.79,64.44) 128.12,64.9 U1JSL.P20 ; v1(130.43,62.56) 130.54,62.49 131.03,62.52 131.3,62.75 131.3,62.85 U1JSL.F23 ; v2(106.67,71.54) 106.67,71.69 106.54,71.82 U1JSL.CB3 106.64,72.54 106.64,73.17 U1JSL.CB1 ; v2(123.97,70.93) 123.74,71.16 U1JSL.AD6 ; U1JSL.A49 134.18,51.65 v1(134.37,51.46) ; v1(134.66,56.91) 134.66,56.92 134.47,57.09 U1JSL.A37 ; U1JSL.B12 133.37,68.39 133.12,68.14 U1JSL.C13 ; U1JSL.F12 U1JSL.F13 ; U1JSL.H1 130.64,73.54 132.36,75.26 v2(132.36,76.17) ; U1JSL.BW2 U1JSL.BW4 ; v1(135.16,51.18) 135.16,51.18 135.16,51.47 134.98,51.65 ; v2(134.69,66.75) U1JSL.A16 133.8,66.78 133,66.85 U1JSL.C16 U1JSL.D16 ; v2(104.97,54.57) 104.76,54.79 U1JSL.CF42 ; U1JSL.CT18 99.78,65.91 99.6,66.09 v2(99.33,66.09) ; U1JSL.D21 U1JSL.C21 U1JSL.A21 133.85,64.36 134.21,64.36 v1(134.28,64.44)
  TOP w0.185: U1JSL.AC47 123.96,52.76 124.34,53.13 v1(124.69,53.3) ; U1JSL.Y45 126.05,53.13 U1JSL.V47
  TOP w0.198: v2(37.86,53.32) 37.81,53.27 U23.11
  TOP w0.203: v2(174.92,30.21) 174.94,30.2 C130.1 ; C74.1 16.94,36.04 v2(17.06,36.17) ; v1(149.47,25.11) 149.68,25.11 149.79,24.99 U17.A8 ; C356.2 41.34,37.23 v2(41.47,37.36) ; Q4.1 165.46,28.98 v1(165.32,28.84) ; R287.2 20.79,31.15 v2(20.47,31.47) ; v2(59.8,12.81) 59.8,13.17 60.44,13.81 R1009.2 ; U31.8 41,34.82 41.6,35.42 v2(41.8,35.42) ; v2(35.11,68.87) 34.38,68.87 34.12,69.13 R27288.2 R27289.2 33.95,70.18 v2(33.65,70.48) ; U21.14 51.12,58.97 v2(51.02,59.08) ; R340.2 92.29,45.87 v2(92.42,46) ; R7D24.2 93.31,47.29 v2(92.8,47.79) ; v2(72.28,23.18) 72.45,23 R278.2 ; R11103.2 99.91,46.28 v2(99.4,46.28) 98.89,46.28 R11111.2 ; R3808.2 96.62,49.03 v2(96.07,49.03) 96.14,49.1 96.14,49.2 96.64,49.69 R7D9.2 ; U17.G1 v1(153.89,19.95) ; v2(180.99,47.28) 180.94,47.33 R232.2 ; D11.2 v2(15.77,48.07) ; v2(8.08,69.06) 8.37,69.35 R223.2 ; v2(180.61,45.02) 181.17,45.02 R437.1 ; U17.A1 148.86,19.32 148.86,18.76 148.45,18.35 v2(148.45,17.55) ; U1JSL.CT34 98.72,58.67 v2(98.57,58.81) ; v2(95.52,58.35) 95.72,58.56 96.06,58.56 R11114.2 ; v2(38.39,55.25) 38.19,55.04 C297.2 C296.2 ; C28011.2 46.4,63.68 v2(46.38,63.65) ; C143.1 26.84,16.55 v2(26.56,16.83) ; v2(14.13,28.3) 14.15,28.33 CR1.2 CR2.2 ; v2(18.43,26.35) 18.9,26.81 R288.2 ; R387.1 v1(97.99,45.49) 97.39,45.49 R11110.2 ; U17.A5 149.71,23.04 149.68,23.07 v1(149.42,23.07) ; U17.M9 157.57,25.64 157.6,25.62 v1(157.62,25.62) ; v2(103.47,57.14) 103.47,56.98 U1JSL.CJ38 ; C1A6.2 84.28,15.4 v2(84.23,15.45) ; R3812.2 96.64,51.45 96.44,51.65 v2(96.28,51.65) 95.74,52.19 RT756.2 ; v2(113.87,73.72) 113.05,74.55 113.05,75.58 112.59,76.03 112.59,77 113.38,77.79 113.38,77.84 v2(113.4,77.86) 113.4,78.07 113.28,78.19 C4102.2 112.63,78.69 112.03,79.28 112.03,79.74 v2(112.41,80.12) 112.41,80.15 111.98,80.58 111.98,81.21 112.51,81.74 115.31,81.74 115.54,81.51 v2(115.54,80.58) 115.72,80.58 115.99,80.3 115.99,79.34 115.35,78.69 C4101.2 114.82,78.61 v2(114.82,77.86) 114.82,77.43 113.88,76.49 113.88,75.08 114.88,74.09 v2(114.88,73.72) 115.05,73.55 U1JSL.BC1 115.04,73.27 U1JSL.BD2 ; v2(51.76,56.19) 51.37,55.81 R231.1 ; v1(96.18,39.63) 96.18,39.65 96.19,39.66 96.19,40.86 C17.2 C10.2 ; v2(128.55,80) R5M19.2 128.55,80.88 128.64,80.97 R461.2 ; v1(166.52,20.56) 166.48,20.6 U13.F4 ; R236.2 180.18,47.36 v2(180.1,47.29) ; R420.2 93.94,69.79 94.15,69.99 v2(94.22,69.99) 94.3,69.91 R4F20.2 ; R2C20.2 92,42.92 92.42,43.34 93.08,43.34 v2(93.13,43.39) ; v2(41.6,44.26) 41.6,44.61 41.45,44.76 C290.2 ; U13.E6 U13.D6 U13.D5 U13.D4 ; U13.E6 U13.F6 U13.F5 U13.F4 ; U13.E6 U13.E5 U13.E4 ; v1(160.42,21.91) 160.78,21.54 R72.2 ; v2(102.25,47.04) 101.92,47.04 101.67,47.29 94.32,47.29 92.53,49.08 92.35,49.08 92.07,49.36 C4104.2 91.52,49.68 v2(91.31,49.9) 91.31,49.92 91.28,49.95 91.28,50.01 91.12,50.18 91.12,51.99 91.47,52.35 92.93,52.35 93.18,52.1 ; v2(12.17,70.79) D7.8 D7.3 14.18,70.79 v2(14.23,70.74) ; v2(23.93,19.69) 23.93,20.18 24.32,20.57 C132.1 C134.2 C133.2 ; C136.1 21.39,18.91 21.25,19.05 v2(20.93,19.05) ; v2(40.02,46.8) 40.02,47.37 40.21,47.56 R298.2 ; C96.2 30.53,48.55 30.75,48.32 v2(31.58,48.32) ; U22.3 181.83,38.26 v2(181.72,38.15) 181.86,38.01 C1001.2 181.86,36.97 181.87,36.95 R444.2 182.07,36.41 v2(182.39,36.41) 182.66,36.41 182.85,36.22 R446.2 ; D2741.3 v2(9.89,73.72) ; U13.E4 U13.D4 ; U13.E4 U13.F4 ; v2(94.55,49.02) C4103.2 ; R285.2 152.34,16.99 v1(152.34,16.39) 152.34,16.17 152.09,15.92 C249.2 151.85,15.75 151.57,16.03 150.76,16.03 C118.2 150.17,17.15 150.49,17.46 C114.2 ; R91362.1 21.4,9.38 v2(21.28,9.26) ; U1JSL.CJ21 103.16,64.62 v1(103.54,65) 103.41,65.13 102.91,65.13 102.36,65.68 U1JSL.CL18 ; v2(101.22,48.38) 101.11,48.27 95.58,48.27 94.99,48.87 94.99,49.82 95.17,50 95.17,52.07 94.96,52.27 93.35,52.27 93.18,52.1 ; D15.2 v2(19.32,48.07) ; R6D38.2 95.78,66.26 v2(95.55,66.03) 95.33,66.25 R1G1.2 ; v2(24.76,9.21) 24.41,8.85 C144.1 ; U1JSL.E52 132.06,50.3 133.24,49.12 133.24,48.53 133.93,47.84 v1(135.76,47.84) ; R6D29.2 94.23,67.37 93.97,67.63 93.47,67.63 v2(93.07,67.23) ; U13.C2 165,20.09 U13.D4 ; v2(99.42,52.88) 99.42,53.09 99.87,53.54 U1JSL.CT45 ; R449.2 R451.2 163.67,72.92 163.34,72.6 v2(163.34,72.32) ; v2(93.18,50.57) v2(93.18,51.26) 93.18,52.1 ; v2(105.73,76.78) 105.67,76.83 R5F9.2 ; C37.2 144.61,28.87 v1(144.82,28.87) ; U1JSL.CT23 100.14,63.44 99.47,63.44 v2(99.21,63.18) ; R311.2 v2(182.8,48.52) 182.46,48.86 C27101.1 ; U1JSL.CT39 99.33,56.25 v2(99.3,56.29) ; v2(9.06,72.02) 8.63,71.58 R222.2 ; R378.2 83.62,11.9 v2(83.24,12.28) ; D14.2 v2(14.75,48.07) ; R11107.2 R11108.2 95.8,55.53 v2(95.54,55.27) 95.56,55.25 R341.2 ; v1(152.44,28.56) 152.61,28.39 152.61,28.05 152.59,28.03 U17.E12 ; U1JSL.CL47 102.49,52.26 v2(102.47,52.25) ; R414.2 92.87,71.5 92.91,71.54 94.02,71.54 v2(94.09,71.47) 94.12,71.47 94.19,71.4 R416.2 ; v2(14.19,22.78) CR5.2 ; C243.2 88.22,15.33 v2(88.42,15.53) ; v2(40.42,44.25) 40.31,44.14 U30.8 ; v2(93.45,72.32) 93.55,72.22 95.95,72.22 96.08,72.35 96.41,72.35 96.64,72.58 96.64,73.21 96.89,73.47 98.82,73.47 99.08,73.22 v2(99.38,73.22) ; v2(137.23,72.2) 137.23,72.22 137.05,72.4 R6F1.2 ; v2(135.77,69.34) 135.63,69.2 U1JSL.A10 ; v2(181.34,43.21) 181.43,43.12 U22.14 ; R91339.1 v2(10.81,33.72) ; U1JSL.CP12 99.68,68.31 v2(99.52,68.46) ; R5G69.2 119.65,75.49 119.31,75.15 v2(119.31,74.33) ; R176.2 73.98,45.62 v2(73.98,45.16) 73.98,44.73 C63.2 ; v2(91.28,74.05) 91.28,74.99 90.77,75.5 90.77,75.96 91.08,76.26 92.57,76.26 v4(93.19,75.64) ; v2(180.71,38.13) 180.71,38.28 181.03,38.6 U22.1 ; R9.2 86.17,44.1 85.67,43.61 v2(85.67,43.26) ; v2(183.02,43.86) 182.72,43.55 182.72,43.01 182.63,42.92 U22.11 ; C62.2 165.93,15.94 v2(165.83,15.84) ; U1JSL.V3 126.03,72.52 126.03,73.18 U1JSL.V1 126.07,73.31 126.07,74.2 126.18,74.31 v1(126.18,74.33) ; U1JSL.AK1 121.01,74.24 121.07,74.31 v1(121.07,74.33) ; v2(94.15,68.97) 94.15,68.91 94.61,68.45 R418.2 ; v1(157.61,21.86) 157.25,21.86 U17.M3 ; v2(112.82,77.86) 112.73,77.77 R6E3.2 R6E5.2 ; v2(122.2,21.39) 122.2,21.07 122.37,20.9 R191.2 ; v2(181.61,47.29) 181.7,47.38 R138.2 ; v2(101.66,62.11) U1JSL.CP26 101.02,62.04 100.27,62.04 U1JSL.CT26 ; v2(104.03,74.11) 104.03,73.37 U1JSL.CG1 ; R302.2 32.62,52.67 31.93,51.98 v2(31.93,51.7) ; U1JSL.CA47 107.06,52.77 106.21,53.62 U1JSL.CC45 ; v2(95.5,60.77) 95.52,60.8 95.96,60.8 R49.2 ; v2(99.76,61.19) 99.86,61.08 U1JSL.CT28 ; v2(101.66,59.7) U1JSL.CP32 ; v2(23.01,17.21) 22.12,17.21 21.95,17.37 R183.2 ; U17.M4 v1(157.6,22.39) ; C1025.2 147.86,16.41 148.35,15.92 v1(148.56,15.92) 148.56,16.82 148.97,17.23 C1027.2 ; U1JSL.CB1 106.54,76.12 v2(107.21,76.78) ; v2(93.81,12.29) 93.75,12.23 C300.2 R297.2 93.29,13.18 93.03,13.44 Q19.1 ; U1JSL.B12 133.49,68.48 136.11,68.48 136.59,68.96 ; R91352.2 R91351.2 78.67,15.35 78.66,15.37 v2(78.66,15.47) ; CR7.2 v2(14.14,30.32) ; U1JSL.CT42 99.72,54.83 v2(99.66,54.76) ; v2(161.19,23.63) 161,23.44 C52.2 160.66,23.08 R27292.2 ; v1(119.65,26.6) 119.44,26.39 C4601.2 ; v2(18.69,17.84) 18.81,17.97 R91358.1 18.81,18.43 18.43,18.43 18.18,18.68 R91359.1 ; v2(14.13,23.79) CR4.2 ; U1JSL.A23 134.52,63.31 v1(134.66,63.45) 135.03,63.81 C6.2 C7.2 138.11,63.81 138.77,63.15 ; v1(155.09,28.56) 155.09,28.51 155.19,28.41 U17.J12 ; R11109.2 v2(93.82,46) ; C159.2 15.31,25.8 v2(15.39,25.72) ; CR6.2 14.29,29.32 v2(14.14,29.17) ; R87.1 v2(6.11,33.72) ; 126.45,25.59 126.8,25.93 C30.2 C35.2 ; v2(128.29,76.13) 128.39,76.24 R406.2 ; U27.D1 66.99,65.59 v2(66.31,65.59) 66.29,65.59 66.11,65.41 R254.2 ; v2(114.34,75.78) 114.27,75.85 114.27,76.31 C29.2 ; v2(119.72,80.25) R394.2 ; v1(121.25,46.55) 121.11,46.55 120.86,46.3 120.86,44.85 C22.2 C14.2 ; C11.2 115.74,77.38 115.56,77.56 v2(115.56,77.86) 115.56,78.08 116.28,78.8 C3423.2 ; CR3.2 v2(14.13,24.81) ; C141.2 v2(29.56,12.43) ; U17.E1 v1(152.92,20.77) ; v2(16.2,19.16) 16.32,19.16 16.6,18.88 R91360.1 ; C140.1 v2(29.56,10.91) ; v2(122.9,74.33) 122.71,74.14 U1JSL.AF1 ; R321.2 89.98,32.38 ; v2(41.51,16.06) 41.51,16.39 42.04,16.91 R422.2 ; C142.2 v2(29.56,11.67)
  TOP w0.25: U1JSL.CJ15 103.02,67.52 v1(103.02,67.68) ; U1JSL.AU18 v2(118.1,65.3) U1JSL.AR18 118.48,65.62 v2(118.81,65.3) 119.19,65.67 U1JSL.AP18 119.29,65.67 v2(119.68,65.3) 120,65.62 U1JSL.AM18 120.01,65.64 v2(120.36,65.3) 120.74,65.66 U1JSL.AK18 120.82,65.67 v2(121.22,65.28) U1JSL.AH18 ; U1JSL.BV47 v2(108.21,52.1) ; U1JSL.CJ28 103.13,61.17 v2(102.77,60.7) 102.62,60.85 U1JSL.CL29 ; U1JSL.CB26 106.64,61.89 v2(106.64,61.63) ; v1(104.08,66.76) 104.13,66.76 104.48,66.42 U1JSL.CF17 ; 133.88,73.27 134.31,73.27 v2(134.38,73.34) ; 133.88,73.27 U1JSL.D1 ; 133.88,73.27 133.83,73.22 U1JSL.A4 U1JSL.B4 ; U1JSL.CE47 105.21,52.86 104.56,52.67 v1(104.53,52.69) ; v1(131.2,72.29) 131.49,72.29 U1JSL.F4 ; v2(101.66,64.53) U1JSL.CL21 102.43,64.53 v1(102.83,64.14) ; v1(121.12,57.28) U1JSL.AH38 ; U1JSL.BP48 110.33,52.19 v1(110.62,52.1) U1JSL.BN47 ; v2(122.78,67.63) 123.21,67.2 U1JSL.AD15 123.49,67.23 123.56,67.23 v2(123.96,67.63) ; v2(122.78,67.63) 122.35,67.2 U1JSL.AG15 ; v2(122.78,67.63) 122.45,67.63 U1JSL.AG13 ; U1JSL.CF13 104.57,68.25 v1(104.92,68.61) ; U1JSL.AG18 v1(122.67,66.03) ; v1(113.03,52.1) 113.03,52.35 U1JSL.BG47 v1(112.97,53.3) ; U1JSL.CJ7 103.19,71 v1(102.86,71) 103.38,71.52 U1JSL.CJ4 ; U1JSL.CJ21 103.16,64.47 v1(102.83,64.14) ; U1JSL.AJ10 121.21,69.18 121.56,69.53 ; U1JSL.CL37 v2(101.73,57.28) ; U1JSL.CL32 v2(101.66,59.7) ; U1JSL.BY42 v2(107.56,54.63) ; v2(134.38,72.58) 134.48,72.2 134.11,71.59 133.83,71.52 U1JSL.A5 U1JSL.B5 ; U1JSL.AB6 124.2,71.16 v2(123.97,70.93) ; U1JSL.CN6 v1(101.34,71.51) ; v1(102.83,64.14) U1JSL.CJ23 102.73,63.26 U1JSL.CL24 ; U1JSL.AG13 122.21,67.92 v2(121.6,68.24) 121.15,67.92 U1JSL.AJ13 121.14,67.88 v2(120.39,68.19) ; U1JSL.AG13 v2(122.81,68.29) ; U1JSL.BP23 109.87,63.69 v2(109.7,63.84) 109.68,63.84 U1JSL.BT23 v2(108.94,63.84) ; U1JSL.CC47 105.77,52.7 v1(105.43,52.36) ; U1JSL.AH18 v2(121.91,66.03) ; U1JSL.AH18 v2(121.91,65.3) ; U1JSL.CL26 v2(101.66,62.11) ; U1JSL.CB32 v2(106.13,58.92) U1JSL.CC32 v2(105.47,58.92) ; U1JSL.CJ34 v2(102.86,58.83) ; v2(102.86,58.83) U1JSL.CL34 ; v2(102.86,58.83) U1JSL.CJ32 ; U1JSL.BM23 110.89,63.49 v1(111.27,63.84) 111.62,63.52 U1JSL.BK23 v2(111.99,63.84) U1JSL.BJ23 ; U1JSL.BH38 v1(112.76,57.38) U1JSL.BF38 ; U1JSL.BB47 v1(115.45,52.1) ; U1JSL.BJ33 v2(112.79,59.49) ; v1(108.63,46.01) 108.08,46.01 107.43,45.37 C24.2 C26.2 ; U1JSL.CL15 v2(101.66,66.94) ; U1JSL.AU47 v1(117.86,52.1)
  TOP w0.254: v2(108.96,62.47) 108.61,62.77 U1JSL.BU25 ; v2(108.96,62.47) 109.34,62.07 U1JSL.BT26 v2(108.98,61.7) ; v2(108.96,62.47) 109.27,62.77 U1JSL.BT25 ; v2(108.96,62.47) 108.58,62.11 U1JSL.BU26 ; R6F3.2 130.1,77.02 130.57,77.49 v2(130.57,77.53) ; U4701.N9 v1(99.45,33.12) ; R154.2 C129.2 161.84,17.16 v1(161.44,16.75) ; C4818.2 103.96,40.09 v1(103.35,39.48) ; U4601.G10 122.89,36.89 v1(122.95,36.89) ; R7D9.2 96.04,49.81 R384.2 ; U4601.D9 v1(122.16,39.49) U4601.C10 ; U24.D1 82.82,58.32 v2(83.22,58.72) ; U4701.W4 95.79,36.7 95.55,36.43 95.55,36.23 U4701.Y5 95.04,35.73 95.04,35.32 95.5,34.86 v1(95.6,34.86) ; C4527.2 128.71,35.72 U4401.J1 129.22,35.61 v1(129.31,35.61) U4401.K2 ; v1(94.97,37.91) 94.97,37.91 94.99,37.88 94.99,37.8 95.21,37.53 U4701.Y3 ; C4518.2 130.93,25.92 v1(130.93,27.1) U4401.AB3 ; U4401.Y5 v1(131.71,29.1) U4401.W4 ; v2(113.13,68.19) U1JSL.BF13 v2(113.13,67.53) U1JSL.BF15 ; U1JSL.T38 U1JSL.R36 v1(127.81,57.98) U1JSL.R34 v1(127.79,58.88) U1JSL.R32 v1(127.79,59.78) ; U1JSL.T38 v1(126.5,56.61) U1JSL.V38 v1(125.6,56.61) U1JSL.Y39 v1(125.6,55.95) U1JSL.Y41 v1(125.6,55.29) U1JSL.Y42 v1(125.6,54.63) U1JSL.Y44 U1JSL.Y45 v1(124.69,53.3) ; U1JSL.T38 127.39,56.65 v1(127.4,56.61) U1JSL.P39 v1(128.3,55.95) U1JSL.P41 v1(128.3,55.29) U1JSL.P42 v1(128.3,54.63) U1JSL.P44 v1(128.3,53.97) U1JSL.P45 ; U4601.P3 v1(117.36,33.02) ; v2(124.94,63.11) U1JSL.Y23 ; v2(124.94,63.11) U1JSL.Y25 ; v2(124.94,63.11) U1JSL.AB25 v2(124.2,63.13) ; v2(124.94,63.11) U1JSL.AB23 ; U1JSL.BW4 108.12,72.02 108.9,71.24 U1JSL.BU6 109.31,71.16 v2(109.39,71.08) ; U14.E7 66.46,44.65 66.29,44.83 v2(66.29,44.89) ; v2(16.27,54.81) 16.26,54.8 D5.8 D5.3 v2(14.24,54.8) ; U4401.T1 128.56,31.65 v1(128.56,31.67) 128.05,31.67 127.55,32.17 C4529.2 ; U1JSL.BT45 v2(109.37,53.97) ; v2(109.37,53.97) U1JSL.BR47 ; v2(109.37,53.97) 109.1,54.16 U1JSL.BT44 v2(109.37,54.63) U1JSL.BT42 v2(109.37,55.29) U1JSL.BT41 v2(109.37,55.95) U1JSL.BT39 ; v1(118.04,26.62) 117.93,26.62 117.47,27.02 U4601.AB3 ; v2(50.27,67.64) 50.25,67.62 Q1010.1 ; U4701.E8 v1(105.29,33.94) ; v2(101.73,57.28) U1JSL.CP37 ; C4535.2 C4522.2 138.51,29.97 138.45,29.91 137.87,29.91 U4401.V12 ; C4535.2 138.24,31.04 v1(138.11,31.17) 137.85,31.39 U4401.T12 ; C4535.2 139.38,31.04 139.44,30.98 C4532.2 ; U4601.P10 v1(122.96,33.01) ; v2(126.13,68.14) 125.85,67.86 U1JSL.W13 125.22,67.86 v2(125.01,67.65) 124.56,67.2 U1JSL.AB15 124.39,67.2 v2(123.96,67.63) ; v2(126.13,68.14) 126.16,68.14 U1JSL.U12 ; v2(126.13,68.14) 126.41,67.86 U1JSL.U13 126.74,67.86 v2(127.02,68.13) 127.29,67.86 U1JSL.R13 127.63,67.86 v2(127.91,68.13) 128.37,68.59 U1JSL.N11 128.47,68.98 v2(128.82,69.33) 128.92,69.43 U1JSL.L10 v2(129.77,69.81) U1JSL.J10 v2(130.4,69.88) ; U4401.G1 128.51,36.97 v1(128.5,36.95) 128.48,36.95 128.44,36.99 C4525.2 ; v2(65.45,45.84) 65.35,45.94 U14.H10 ; U1JSL.H41 U1JSL.H39 ; U1JSL.H41 v1(131.01,55.29) U1JSL.H42 v1(131.01,54.63) ; U1JSL.H41 v1(131.01,55.95) U1JSL.H39 ; U1JSL.H39 v1(131.01,56.61) ; U4601.D2 v1(116.58,39.5) ; C4517.2 128.26,28.83 v1(128.53,29.1) 128.91,28.79 U4401.Y1 ; v1(110.27,56.61) 109.87,56.9 U1JSL.BP38 ; U1JSL.AV45 v1(117.48,53.97) ; v1(96.17,35.51) 96.17,35.52 U4701.V5 ; C4812.2 106.74,39.68 v1(106.62,39.56) 106.57,39.5 U4701.C1 ; U4701.P10 v1(99.46,32.3) ; v2(77.81,10.31) 77.68,10.44 U5.B3 ; U1JSL.BT28 v2(108.98,61.7) ; v2(108.98,61.7) U1JSL.BU28 v2(108.96,60.96) ; v2(108.98,61.7) U1JSL.BU26 ; U4301.W9 v1(156.7,44.04) U4301.Y8 ; U4601.T12 124.23,31.38 124.58,31.15 v1(124.61,31.15) 124.72,31.04 C4841.2 ; v1(106.62,29.86) 106.62,29.89 106.57,29.95 U4701.C12 ; U4401.G3 130.89,37.61 v1(130.89,38.2) ; U4701.P12 99.13,30.1 v1(99.42,29.81) ; U1JSL.U23 v2(126.46,63.11) U1JSL.U25 ; U4401.A3 130.85,41.41 v1(130.86,41.45) 130.86,41.48 131.18,41.81 C4510.2 ; v2(74.99,48.29) 74.99,48.26 R174.2 ; U1JSL.AH47 121.55,52.66 121.96,53.27 U1JSL.AF45 ; C4534.2 138.18,32.31 v1(138.13,32.36) 138.11,32.38 U4401.P12 ; v1(165.38,25.98) 165.22,25.81 C51.2 ; C38.2 146.41,29.35 v1(146.58,29.35) ; R370.2 36.9,64.7 36.63,64.98 36.63,65.23 v2(36.52,65.34) ; 128.64,20.58 128.64,20.77 v2(128.44,20.97) ; C4512.2 158.76,39.3 v1(158.71,39.34) U4301.AB3 ; U1JSL.L32 v1(129.77,59.78) ; U1JSL.AB20 U1JSL.AB18 ; U1JSL.AB18 v1(124.2,66.09) U1JSL.AB17 U1JSL.Y17 v1(125.72,66.09) ; U1JSL.AB18 U1JSL.Y18 ; U4601.V5 v1(118.96,30.4) ; U1JSL.F34 v1(132.36,58.48) ; U1JSL.F29 v1(132.36,60.9) ; v1(116.56,31.68) 116.57,31.69 U4601.T3 ; U4401.G10 135.72,36.9 v1(135.72,36.87) ; U4601.N4 v1(118.16,33.01) ; U4701.T12 v1(98.15,30.7) ; U4701.Y12 95.22,30.26 v1(94.87,29.92) 95.11,29.68 95.11,29.68 C4820.2 ; v1(122.95,27.83) 122.91,27.83 U4601.AB10 122.56,25.98 C4806.2 ; C33.2 101.87,26.98 v2(101.36,26.48) ; U4601.T8 v1(121.36,31.05) ; C4301.2 155.76,36.88 156.05,37.17 v1(156.05,37.64) U4301.V1 ; U1JSL.CR1 100.63,73.24 99.41,73.24 v2(99.38,73.22) ; v2(126.09,70.17) U1JSL.W9 v2(126.09,69.51) U1JSL.W10 125.35,69.47 125.15,69.47 v2(125,69.62) U1JSL.AB10 124.25,69.18 v2(123.97,68.9) 123.69,69.18 U1JSL.AD10 ; v2(65.95,47.43) 65.95,46.95 U14.K8 ; U4401.K4 v1(131.72,35.58) ; C4508.2 147,47.3 v1(146.97,47.26) U4301.E12 ; U26.D1 88.76,35.08 89.5,35.83 v2(90.04,35.83) ; v2(108.94,63.84) U1JSL.BU21 v2(108.25,63.85) ; v2(108.94,63.84) U1JSL.BT21 v2(109.7,63.84) 109.87,64 U1JSL.BP21 ; v2(108.94,63.84) 108.92,63.84 U1JSL.BU23 v2(108.25,63.85) ; U14.J5 v2(66.69,46.44) ; U1JSL.AR33 118.5,59.15 v2(118.86,59.51) ; U1JSL.BM38 v1(111.17,56.61) ; 142.51,20.68 v2(142.51,21.07) ; v2(124.2,63.13) U1JSL.AC25 ; v2(124.2,63.13) 124.18,63.13 U1JSL.AC23 ; U1JSL.F37 131.36,57.05 131,56.62 v1(131.01,56.61) ; U1JSL.CJ52 103.38,50.23 103.15,49.98 v2(103.15,49.96) ; R283.2 116.89,83.72 116.44,84.16 116.25,84.16 115.74,84.67 v2(115.74,84.77) ; C4505.2 157.41,37.58 v1(157.35,37.64) U4301.Y1 ; v1(131.01,54.63) U1JSL.F43 ; v1(131.01,54.63) U1JSL.H44 v1(131.01,53.97) U1JSL.H45 U1JSL.H46 v1(130.77,52.57) ; R458.2 164.74,72.55 v2(164.79,72.5) ; U1JSL.L6 128.98,71.86 ; 128.98,71.86 U1JSL.N3 ; 128.98,71.86 U1JSL.K5 ; 108.96,60.24 U1JSL.BT30 109.18,60.76 v2(108.96,60.96) ; 108.96,60.24 U1JSL.BU31 ; 108.96,60.24 U1JSL.BT31 109.32,59.87 v2(108.96,59.51) ; C4819.2 105.27,29.85 v1(105.29,29.86) 105.29,29.89 105.24,29.95 U4701.E12 ; U1JSL.BE23 v2(113.51,63.84) ; v2(113.51,63.84) U1JSL.BG23 ; v2(113.51,63.84) U1JSL.BE21 ; v2(113.51,63.84) U1JSL.BG21 ; U4401.D2 v1(129.31,39.5) ; U1JSL.CD38 105.96,56.61 106.21,56.35 U1JSL.CC39 v2(106.66,55.95) ; U4401.N11 v1(137.27,33.02) ; U4601.N9 121.9,33.34 v1(122.16,33.13) ; U1JSL.AE17 v1(122.67,66.03) ; v1(122.67,66.03) U1JSL.AG17 v2(121.91,66.03) ; v1(122.67,66.03) U1JSL.AE18 ; v1(170.33,17.97) 170.12,18.17 R1022.2 ; U4601.G12 v1(123.76,36.9) ; v2(121.91,66.03) U1JSL.AG18 v2(121.91,65.3) ; v2(121.91,66.03) U1JSL.AH17 ; U1JSL.R26 U1JSL.U26 ; U1JSL.R26 v1(127.79,62.56) 128.13,62.1 U1JSL.P26 128.11,62.1 v1(128.45,62.56) 128.79,62.1 U1JSL.M26 128.77,62.1 v1(129.11,62.56) 129.45,62.1 U1JSL.L26 129.43,62.1 v1(129.77,62.56) 130.11,62.1 U1JSL.J26 130.09,62.1 v1(130.43,62.56) 130.77,62.1 U1JSL.H26 U1JSL.F26 ; U1JSL.R26 v1(127.79,61.59) U1JSL.R28 v1(127.79,60.68) ; v1(129.16,52.06) U1JSL.M47 U1JSL.K47 129.92,52.86 130.29,52.86 U1JSL.J47 130.4,52.86 v1(130.77,52.57) ; C4804.2 124.59,29.72 v1(124.56,29.75) U4601.V12 ; U4601.P1 v1(114.94,33) 114.36,33.58 C4837.2 ; U1JSL.CM10 101.64,69.45 v1(101.59,69.51) ; C4520.2 136.64,41.71 136.47,41.54 v1(136.47,41.51) 136.47,41.51 U4401.A10 ; v2(26.8,58.72) 26.61,58.52 R375.2 ; C4829.2 109.94,31.46 v1(110.26,31.14) ; U4401.J12 138.11,36.2 v1(138.13,36.21) 138.29,36.38 C4530.2 ; U4701.G12 v1(103.35,30.71) ; v2(99.67,70.42) 99.8,70.29 U1JSL.CT8 ; v1(117.36,35.61) U4601.J3 U4601.K2 ; U4301.P3 v1(152.79,40.05) ; v2(117.49,84.77) 117.49,84.64 118.16,83.98 R279.2 ; U4301.J3 v1(150.19,39.25) 150.53,38.91 U4301.K2 ; U4701.T3 v1(97.5,37.13) ; U4401.P3 v1(130.91,33.02) ; U1JSL.CD6 105.25,71.1 105.25,70.7 U1JSL.CD7 105.15,70.61 v1(104.94,70.4) 105.23,70.11 U1JSL.CE9 ; v1(105.29,39.5) 105.02,39.12 U4701.E1 ; U1JSL.BU34 v2(108.19,58.79) U1JSL.BU33 108.73,59.3 108.95,59.51 v2(108.96,59.51) ; v1(128.45,59.78) U1JSL.P32 v1(127.79,59.78) ; U4701.W9 v1(95.55,33.11) 95.55,33.13 95.25,33.51 U4701.Y8 ; U4701.K2 v1(102.05,37.91) ; U1JSL.AT38 v1(118.38,56.61) U1JSL.AP38 ; v2(88.42,15.53) 88.42,15.7 87.95,16.17 Q16.3 ; U1JSL.V30 U1JSL.V28 126.07,61.31 v2(125.67,61.56) 126.1,62 U1JSL.V26 ; C4835.2 102.61,29.72 v1(102.67,29.89) U4701.J12 ; C3609.2 91.73,73.53 91.28,73.98 v2(91.28,74.05) ; U1JSL.E7 132.3,70.66 v2(132.76,70.66) 132.76,71.04 U1JSL.D6 ; U4401.D11 137.31,39.49 137.32,39.5 v1(137.34,39.5) ; U4401.W11 v1(137.31,29.75) ; C4821.2 94.92,39.9 v1(95.23,39.59) U4701.Y1 ; v2(120.39,68.19) 119.93,67.85 U1JSL.AM13 119.86,67.85 v2(119.26,68.16) 118.84,67.85 U1JSL.AR13 ; U1JSL.AG33 v2(121.91,59.51) U1JSL.AH33 v2(121.91,58.79) U1JSL.AG33 ; U1JSL.AG33 U1JSL.AE33 v2(123.43,59.51) U1JSL.AC33 U1JSL.AB33 U1JSL.Y33 v2(125.72,59.51) U1JSL.V33 ; U1JSL.CE24 104.82,63.29 v1(104.82,63.32) ; U4601.G3 v1(117.36,36.91) ; U1JSL.CM1 101.96,73.32 102.33,73.69 v2(102.33,73.85) ; R372.2 38.66,65.05 v2(38.37,65.34) 38.37,65.14 37.94,64.7 R371.2 ; v2(110.46,66) 110.79,65.66 U1JSL.BM18 U1JSL.BM20 U1JSL.BM21 110.89,64.22 v1(111.27,63.84) 111.62,64.19 U1JSL.BK21 v2(111.99,63.84) U1JSL.BJ21 ; v2(110.46,66) 110.85,66.39 U1JSL.BM17 111.24,66.77 U1JSL.BL15 ; v2(110.46,66) 110.1,66.36 U1JSL.BP17 ; v2(99.42,52.88) 99.6,52.88 U1JSL.CT48 ; U1JSL.BU26 108.58,62.07 v2(108.19,62.47) ; v2(67.73,49.8) 67.96,49.58 U14.P4 ; U4301.V12 v1(156.05,47.24) ; v1(131.2,72.29) 131.15,72.24 U1JSL.G5 131.32,71.81 v1(131.54,71.59) ; U4701.N4 v1(99.45,36.31) ; J11.A1 6.69,76.6 v2(6.79,76.69) ; U1JSL.F13 131.79,68.17 132.3,68.17 132.33,68.13 v2(132.35,68.13) 132.37,68.13 132.37,68.14 U1JSL.C13 ; U4701.G1 103.65,39.11 v1(103.35,39.48) ; U1JSL.AV39 v1(116.58,55.95) U1JSL.AY39 v1(115.68,55.95) U1JSL.BB39 v1(114.78,55.95) ; U1JSL.AV39 v1(116.58,56.61) U1JSL.AY38 v1(115.68,56.61) U1JSL.BB38 v1(114.78,56.61) U1JSL.BD39 v1(114.78,55.95) ; U1JSL.AV39 v1(117.48,55.95) U1JSL.AV41 v1(117.48,55.29) U1JSL.AV42 v1(117.48,54.63) U1JSL.AV44 ; U1JSL.BW13 107.75,68.11 v2(107.55,68.11) ; U14.N5 U14.P6 66.95,48.95 66.95,49.21 v2(66.34,49.82) ; v2(131.81,20.89) 132,20.7 132,20.58 ; v1(103.35,39.48) 103.35,40.1 103.39,40.14 C4827.2 ; U1JSL.R9 127.88,70.27 v1(127.92,70.27) ; U4301.Y12 v1(157.35,47.24) ; U4401.W9 v1(134.91,29.1) U4401.Y8 ; U4401.G5 v1(132.51,36.91) ; U1JSL.BF2 U1JSL.BF4 ; U1JSL.BF4 113.98,71.82 114.42,71.82 U1JSL.BD4 U1JSL.BD2 ; U1JSL.BF4 v2(113.32,71.57) ; U4301.T1 v1(154.1,37.64) ; U4301.AB10 v1(158.65,44.84) 159.25,44.84 159.53,45.13 C4513.2 ; U1JSL.P16 v1(128.45,67.16) ; v1(170.25,20.03) 170.25,20 169.94,19.7 R69.2 ; R61.2 171.19,21.49 170.9,21.77 170.78,21.77 170.37,22.18 170.37,22.52 v1(170.36,22.53) 170.36,22.31 170.03,21.98 R1024.2 ; C4828.2 139.19,38.22 138.57,38.83 v1(138.12,38.83) 138.11,38.82 U4401.E12 ; v1(132.56,38.84) 132.54,38.84 U4401.E5 ; v2(108.96,59.51) U1JSL.BT33 ; U4401.AB5 v1(132.51,27.8) ; U1JSL.BJ9 v2(113.17,70.24) U1JSL.BF9 113.61,69.83 v2(114.38,70.14) 114.81,69.84 U1JSL.BC9 115.29,69.51 U1JSL.BA10 ; C21.2 163.62,31.28 v2(163.59,31.3) ; U4401.J3 v1(130.91,35.61) ; v2(111.2,59.55) U1JSL.BM33 v2(111.26,58.81) ; C4808.2 121.97,41.7 v1(122.17,41.49) 122.54,41.12 U4601.A10 ; U4701.G10 v1(103.37,32.31) ; v1(158.12,36.69) 158.04,36.61 C4533.2 ; v1(118.17,37.54) 118.2,37.53 U4601.G5 ; 89.98,32.38 89.53,31.92 C4701.2 89.53,30.59 v2(89.73,30.39) ; R46.2 117.75,76.31 v2(117.75,73.72) ; U4601.AB8 v1(120.56,27.8) ; U4601.Y5 v1(118.16,29.1) U4601.W4 ; U1JSL.CN47 101.96,52.8 v2(101.96,52.8) ; 58.52,35.73 U33.12 ; C4840.2 125.19,33.08 124.57,33.08 U4601.P12 v1(123.76,33) U4601.N11 ; U4301.C1 v1(145.64,37.62) 145.66,37.59 C4502.2 ; 121.56,69.53 121.92,69.53 U1JSL.AG9 122.25,69.84 v2(122.83,70.52) ; v1(124.57,38.83) 124.56,38.84 U4601.E12 ; U4601.K9 v1(122.16,35.61) U4601.J10 ; U1JSL.AF45 v1(122.89,53.3) U1JSL.AF47 v1(122.69,52.1) ; U1JSL.AF45 U1JSL.AF44 v1(122.89,54.63) U1JSL.AF42 v1(122.89,55.29) U1JSL.AF41 v1(122.89,55.84) U1JSL.AF39 v1(122.89,56.61) U1JSL.AD38 123.67,57.08 123.92,57.08 U1JSL.AB38 ; U4301.AB8 v1(158,43.24) ; 110.77,71.93 111.24,71.47 U1JSL.BL6 ; U4401.E8 134.08,38.84 134.03,38.84 v1(134.03,38.84) ; v2(110.44,59.55) U1JSL.BP33 ; v1(107.25,31.49) 107.25,31.49 107.25,31.51 U4701.A10 ; U4401.Y10 v1(135.71,28.45) ; U4401.N2 v1(129.31,33.01) 129.24,33.01 U4401.P1 ; U1JSL.V17 126.1,66.39 v1(125.72,66.09) ; U4601.K4 v1(118.16,35.58) ; U4401.AB8 v1(134.11,27.8) ; U4701.AB5 v1(94.18,35.47) ; v2(104.16,58.03) 104.16,57.88 U1JSL.CF36 ; U4401.V8 v1(134.91,30.4) ; v1(121.12,57.28) U1JSL.AK38 v1(120.19,56.61) U1JSL.AM39 v1(120.19,55.95) U1JSL.AM41 v1(120.19,55.29) U1JSL.AM42 v1(120.19,54.63) U1JSL.AM44 U1JSL.AM45 ; U4601.C3 v1(116.58,40.15) ; U4701.T10 v1(97.51,32.3) ; v2(118.1,71.39) 118.08,71.39 118.07,71.38 118.03,71.39 118.02,71.38 117.91,71.4 117.58,71.16 U1JSL.AU6 ; U1JSL.CK43 102.84,54.16 102.82,54.01 v2(102.82,54) 102.84,54.04 U1JSL.CH43 ; v2(126.97,71.39) 126.77,71.39 U1JSL.U6 ; U4301.C3 v1(146.31,39.24) ; U1JSL.BB33 v2(115.83,58.77) U1JSL.AY33 116.21,59.15 v2(116.58,59.51) ; U4701.Y10 v1(94.93,31.51) ; U1JSL.BK41 v1(112.07,55.29) ; v1(99.42,29.81) 99.12,29.5 C4822.2 ; v1(99.42,29.81) 99.69,29.15 C4834.2 ; U1JSL.BK39 v1(112.07,55.95) ; v1(134.06,36.94) 134.07,36.94 134.11,36.93 U4401.G8 ; C4539.2 144.31,44.83 v1(144.35,44.87) 144.35,44.95 144.64,45.24 U4301.A10 ; v2(67.96,45.58) 67.82,45.44 U14.G5 ; 107.48,66.03 v2(107.48,66.02) ; 107.48,66.03 107.14,66.39 U1JSL.CA17 ; 107.48,66.03 107.48,66.03 107.48,66.07 U1JSL.BW17 ; C4541.2 152.39,37.22 v1(152.8,37.63) U4301.P1 ; v2(39.88,65.32) 40.12,65.08 R373.2 ; v1(114.78,55.95) U1JSL.BD41 v1(114.78,55.29) U1JSL.BD42 v1(114.78,54.63) U1JSL.BD44 U1JSL.BD45 v1(114.78,53.3) 114.67,53.29 114.29,52.77 U1JSL.BE47 ; D2742.3 v2(16.81,57.86) ; U1JSL.AM45 120.3,53.16 v1(120.3,53.16) U1JSL.AL47 v1(120.28,52.1) ; U1JSL.AM45 119.13,53.03 U1JSL.AP47 ; U4401.T3 v1(130.91,31.7) ; U1JSL.CB34 v2(106.13,58.01) U1JSL.CB36 ; v1(131.01,56.61) U1JSL.H38 v1(130.1,56.61) U1JSL.K38 v1(129.2,56.61) U1JSL.M38 ; C39.2 162,44.72 v1(162.65,44.06) 162.5,43.9 C40.2 ; v2(117.08,70.17) 116.65,69.86 U1JSL.AW9 ; U1JSL.BD21 v2(115.03,63.84) ; v2(115.03,63.84) U1JSL.BD23 ; v2(115.03,63.84) U1JSL.BB23 v2(115.8,63.84) U1JSL.BB21 U1JSL.BB20 v2(115.79,65.3) U1JSL.BB18 v2(115.83,66.03) U1JSL.BB17 ; U4301.T5 v1(154.73,41.64) ; C4536.2 153.35,47.36 v1(153.44,47.27) 153.44,47.26 U4301.P12 ; v1(130.77,52.57) 131.45,52.78 U1JSL.F47 ; v2(120.39,59.51) U1JSL.AM33 ; v2(130.4,69.88) U1JSL.H10 130.74,69.49 v2(130.99,69.88) 131.32,69.42 U1JSL.G10 131.38,69.39 v2(131.73,69.12) 131.54,68.73 U1JSL.F12 ; v2(130.4,69.88) U1JSL.H8 ; U4701.V8 v1(96.2,33.91) ; C294.2 178.54,30.44 178.96,30.86 178.96,31.1 v2(178.96,31.13) ; C31.2 v1(158.9,30.52) ; C4521.2 143.88,39.04 144.05,39.22 144.97,39.22 v1(145.01,39.25) U4301.A3 ; 135.81,20.58 v2(135.81,20.89) ; U1JSL.BU17 v2(108.94,66.01) U1JSL.BT17 109.34,67.24 v2(109.69,67.59) ; C4538.2 149.67,47.14 149.88,46.93 U4301.J12 149.88,46.77 v1(150.23,46.42) ; v1(145.46,47.36) 145.46,47.33 U4301.C12 ; U1JSL.AY23 v2(116.56,63.84) ; U4301.D2 v1(146.31,38.44) ; v2(101.84,49.96) 101.96,50.08 U1JSL.CM52 ; v1(159.98,42) 160.26,42.29 C4537.2 ; U14.A6 67,42.4 67,41.8 66.85,41.65 v2(66.85,41.62) ; U4601.V8 v1(120.56,29.77) ; U4701.J3 v1(102.06,37.11) ; U1JSL.CC45 106.27,53.68 v2(106.66,53.97) 106.37,54.18 U1JSL.CC44 ; U4301.T12 154.75,47.25 v1(154.75,47.27) ; U1JSL.H16 v1(131.09,67.16) ; v1(102.05,39.48) 102.35,39.11 U4701.J1 ; U4601.T5 v1(118.96,31.7) ; U4701.N11 v1(99.44,30.68) ; U4401.V5 v1(132.51,29.77) ; U4301.J10 v1(150.19,44.85) 150.53,44.51 U4301.K9 ; v2(104.73,49.54) 104.73,50.63 U1JSL.CF52 ; v1(114.94,38.83) 114.96,38.84 U4601.E1 ; U4301.G1 v1(148.26,38.44) ; v1(134.92,54.42) 134.7,54.64 U1JSL.A43 ; v1(114.96,40.16) 114.96,40.13 U4601.C1 ; U4601.Y8 v1(121.36,29.1) U4601.W9 ; U4301.T8 v1(154.75,43.24) ; J11.A12 6.92,71.1 7.6,70.42 7.6,69.13 v2(6.79,68.32) ; R60.2 R1024.2 ; R1024.2 R1023.2 R66.2 ; U4301.D4 v1(146.29,40.84) ; U4301.J1 v1(149.57,37.63) ; U1JSL.CT5 99.7,71.5 v2(99.59,71.62) 100.12,72.15 U1JSL.CT4 ; U40.B1 185.86,35.46 186.36,35.96 v2(186.75,35.96) ; U4401.C5 v1(131.71,39.51) U4401.D4 ; U1JSL.AU10 118,68.73 v2(118,68.24) ; U4401.Y12 138.11,28.45 v1(138.11,28.45) ; U1JSL.AW33 116.98,59.15 v2(117.34,59.51) ; C4802.2 92.39,37.11 94.1,37.11 94.15,37.05 v1(94.18,37.05) 94.15,37.08 94.15,37.28 U4701.AB3 ; U4701.D9 v1(105.95,33.11) ; v2(117.1,68.19) U1JSL.AW13 ; U4301.W11 v1(156.7,46.44) ; U1JSL.F31 U1JSL.H32 v1(130.43,59.78) U1JSL.J32 ; U4601.E5 v1(119.01,38.21) ; C4810.2 114.8,29.59 v1(114.96,29.75) U4601.V1 ; C4838.2 114.94,31.68 v1(114.96,31.7) U4601.T1 ; U36.2 176.93,27.32 v4(176.8,27.19) 177.84,27.19 178.4,26.63 178.4,24.63 C298.2 ; C4826.2 113.18,36.95 C4836.2 114.92,36.95 v1(114.93,36.95) U4601.G1 ; C4839.2 124.48,36.16 U4601.J12 v1(123.76,35.6) ; C4817.2 116.65,41.53 116.58,41.46 v1(116.58,41.41) 116.62,41.41 U4601.A3 ; U1JSL.CR50 100.51,51 U1JSL.CT51 99.71,51 99.07,51.64 v2(99.07,51.74) ; U4401.P10 v1(135.71,32.36) ; U4701.V12 v1(96.21,29.89) ; 126.47,20.58 v2(126.47,20.89) ; U4701.D11 v1(105.95,30.71) ; v1(125.72,66.09) 126.1,65.67 U1JSL.V18 ; v1(125.72,66.09) 125.34,65.67 U1JSL.Y18 ; U4301.W2 v1(156.7,38.44) ; v2(108.25,63.85) U1JSL.BW21 107.69,64.09 107.18,64.09 U1JSL.CA21 ; U1JSL.BA15 115.62,67.18 v2(115.29,67.43) ; U4301.V5 v1(155.4,40.84) ; U4601.Y1 115.1,28.45 v1(114.98,28.44) ; U4601.D4 118.16,39.5 v1(118.18,39.49) 118.18,39.52 U4601.C5 ; 139.73,20.68 139.73,20.78 v2(140.03,21.07) ; U4701.N2 v1(99.45,37.91) ; U1JSL.BK42 v1(112.07,54.63) U1JSL.BK44 U1JSL.BK45 U1JSL.BK47 ; U4701.W11 v1(95.55,30.71) ; U4701.D2 v1(105.95,38.71) ; v1(124.56,28.45) U4601.Y12 U4601.W11 ; v2(89.96,39.05) 89.96,39.41 90.09,39.54 C314.1 ; v1(93.9,34.1) U4701.AB8 ; v1(127.79,59.78) U1JSL.R30 ; U4601.N2 v1(116.57,32.99) ; U4701.A3 108.02,37.22 v1(108.16,37.12) ; v1(133.86,26.35) 133.86,26.24 C4401.2 ; U1JSL.F23 v1(132.36,63.31) U1JSL.C23 ; U4301.G12 v1(148.88,46.44) ; D13.2 20.83,47.62 v2(20.56,47.62) ; U4701.P3 v1(99.47,37.12) ; U4401.N9 v1(135.71,33.01) ; v2(14.55,66.39) U6582.2 ; U4401.W2 129.34,29.72 v1(129.33,29.72) 128.98,30.07 U4401.V1 128.53,30.14 128.52,30.13 128.47,30.14 128.47,30.13 127.49,30.13 C4507.2 ; U1JSL.BA6 115.62,71.14 v2(115.29,71.39) ; v1(105.44,65.01) 105.44,64.89 U1JSL.CE21 ; U4301.C10 v1(146.3,44.87) ; U4601.T10 v1(122.96,31.67) ; U4601.E8 v1(120.56,38.24) ; U4701.C3 v1(105.98,37.1) ; U4401.C3 v1(130.89,40.15) ; U4701.K9 v1(102.04,33.12) ; U4301.G3 v1(148.26,39.24) ; U1JSL.BL10 111.11,69.18 110.89,69.4 v2(110.76,69.4) 110.6,69.4 U1JSL.BP9 109.78,69.46 v2(109.71,69.46) 109.18,69.46 U1JSL.BU10 108.88,69.18 108.6,69.46 v2(108.52,69.46) 108.36,69.46 108,69.81 U1JSL.BW9 108,69.87 107.65,70.22 v2(107.55,70.22) 107.43,70.22 107.1,69.89 U1JSL.CA9 106.87,69.61 v2(106.62,69.61) ; U4301.D9 v1(146.29,44.05) ; v1(112.07,56.61) U1JSL.BH38 ; U4301.T10 v1(154.75,45.64) ; U1JSL.AM6 120.32,71.16 v2(120.49,71.33) 120.66,71.16 U1JSL.AJ6 ; U4301.T3 v1(154.1,40.04) ; U4401.C8 v1(134.91,39.51) U4401.D9 ; U4401.K11 U4401.J10 v1(135.71,35.6) U4401.K9 ; U4401.C10 136.11,39.87 136.45,40.15 v1(136.48,40.15) ; U1JSL.CJ38 103.16,56.64 v2(102.83,56.33) 102.23,56.01 U1JSL.CL40 ; U1JSL.AR9 118.94,69.84 v2(119.27,70.17) ; v1(96.15,38.71) 96.16,38.66 U4701.W2 ; U4301.K4 v1(150.2,40.85) ; U4301.AB5 v1(158,41.64) ; U4601.D11 v1(123.76,39.5) ; C4825.2 99.56,39.65 v1(99.41,39.5) U4701.P1 ; v2(46.25,59.5) 46.83,59.5 ; U4701.K11 v1(102.04,30.72) ; U4301.C5 v1(145.62,41.66) ; U1JSL.F40 v1(132.36,56.07) ; U4601.C12 124.36,39.81 v1(124.61,40.02) ; U4401.T10 v1(136.51,31.7) ; U4301.P10 v1(152.79,44.85) U4301.N9 ; U4301.N11 v1(152.79,46.45) ; C28.2 C27.2 132.94,46.5 132.76,46.32 v1(132.51,46.32) ; v2(102.76,26.48) 102.76,26.92 C36.2 ; v2(108.96,60.96) U1JSL.BU30 ; U4401.Y3 v1(130.11,28.45) ; v1(138.12,40.16) U4401.C12 ; U4301.D11 v1(146.3,46.44) ; U4701.T5 v1(98.14,35.48) ; U4301.G10 148.58,45.19 v1(148.25,44.87) ; U4701.C10 v1(106.6,31.51) ; U4301.Y5 v1(156.7,40.84) U4301.W4 ; U4301.E1 v1(147.62,37.64) ; U4301.K11 v1(150.2,45.62) ; U1JSL.L16 v1(129.77,67.16) ; U4401.N4 v1(131.71,33.01) ; U4701.K4 v1(102.04,36.31) ; U4301.G8 v1(148.89,44.05) ; U1JSL.CE30 v2(104.81,59.82) ; v1(151.16,37.56) 151.12,37.53 C4540.2 ; U4301.N4 152.78,40.83 152.89,40.84 v1(152.89,40.85) ; v1(104.04,35.46) U4701.G5 ; C4823.2 93.55,32.26 v1(93.6,32.31) U4701.AB10 ; U4601.C8 v1(121.36,39.5) ; U4701.T8 v1(97.5,33.91) ; U4701.C8 v1(106.59,33.94) ; U4301.Y3 v1(156.7,39.24) ; U1JSL.AA47 v1(125.11,52.1) ; U1JSL.Y18 U1JSL.Y20 ; U4301.Y10 v1(157.35,44.84) ; U4701.G3 v1(104.01,37.11) ; U4401.T5 v1(132.51,31.04) ; U4301.G5 v1(148.3,41.65) ; U4401.G12 v1(137.31,36.9) ; U4701.E5 v1(105.29,35.48) ; U4401.E1 v1(128.52,38.81) ; U4601.Y3 v1(116.56,28.42) ; U4401.T8 v1(134.91,31.05) ; U4401.C1 v1(128.51,40.19) ; U4701.J10 v1(102.06,32.3) ; U4301.V8 v1(155.4,44.04) ; v1(96.18,39.63) U4701.V1 ; U4701.G8 v1(103.99,33.95) ; U4301.N2 v1(152.79,38.45) ; U4601.AB5 v1(118.96,27.76) ; U4701.D4 v1(105.31,36.31) ; U4601.K11 v1(122.94,35.6) ; U1JSL.M32 v1(129.11,59.78) ; C34.2 v1(159.66,30.52) ; U4601.W2 v1(115.76,29.75) ; U4601.J1 v1(114.93,35.64) ; U4701.C5 v1(106.59,35.48) ; U4301.E5 v1(146.96,41.67) ; U1JSL.R47 v1(127.64,52.1) ; U4601.Y10 v1(122.96,28.45) ; U4301.E8 v1(147.59,43.21) ; U4601.G8 v1(120.56,36.94) ; U4401.AB10 v1(135.71,27.15) 135.71,26.02 C4519.2 ; U4301.C8 v1(145.64,44.05)
  TOP w0.305: U1.17 170.41,27.34 U1.25 171.91,27.34 U1.2 ; U1JSL.AC20 123.84,64.94 v1(124.22,64.51) ; U4.29 24.03,16.56 v2(23.77,16.83) 23.53,16.59 U4.30 ; v1(124.22,64.51) 124.58,64.91 U1JSL.AB20 v2(124.96,64.51) ; v1(124.22,64.51) 123.84,64.21 U1JSL.AC21 U1JSL.AC23 ; v1(124.22,64.51) 124.57,64.24 U1JSL.AB21 ; C386.2 181.82,35.33 v2(181.73,35.24) ; U4.17 27.36,11.58 27.58,11.36 27.58,11.01 v2(27.55,10.98) ; v2(124.96,64.51) U1JSL.AB21 ; v2(124.96,64.51) U1JSL.Y21 U1JSL.Y23 ; v2(124.96,64.51) U1JSL.Y20 ; v2(23.01,18.86) 23.01,18.98 22.75,19.24 22.24,19.24 21.85,19.63 U2.16 ; U2.4 16.73,23 16.3,23.43 v2(16.15,23.43) ; v2(124.2,63.13) U1JSL.AB23 U1JSL.AB21 ; U2.26 21.35,26.09 v2(21.5,26.24) 21.63,26.24 21.85,26.03 U2.25 ; U4.4 21.09,13.58 v2(20.77,13.9) ; U4.16 26.03,10.25 26.15,10.13 v2(26.15,9.84) 25.75,9.84 25.53,10.06 U4.15 ; v2(22.88,60.77) 22.62,60.51 U37.14 ; U2.17 21.88,21 v2(21.48,21.4) 21.35,21.27 U2.15 ; v2(121.91,58.79) 122.27,58.43 U1JSL.AG34 ; v2(126.48,64.51) U1JSL.V21 ; v2(126.48,64.51) U1JSL.U20 ; v2(126.48,64.51) U1JSL.U21 ; v2(126.48,64.51) U1JSL.V20 ; U2.29 19.85,26.08 v2(19.58,26.35) 19.35,26.12 U2.30 ; U4.26 25.53,16.56 v2(25.8,16.83) 26.03,16.59 U4.25
  TOP w0.356: v2(18.88,30.95) 18.92,30.92 U34.5
  TOP w0.381: C80.2 20.85,32.83 v2(20.97,32.7) ; v2(39.39,46.8) 39.39,46.47 39.31,46.39 C358.2 ; v2(9.06,72.02) 9.2,72.02 9.56,72.38 C181.2 ; C10711.2 v2(98.05,22.44) ; v2(14.13,27.71) 14.08,27.75 J9.6 ; C403.1 179.57,61.88 178.83,61.15 178.83,60.67 178.76,60.59 v2(178.76,60.56) ; v2(31.98,50.75) 31.87,50.86 U35.2 ; v2(29.18,57.43) 28.68,57.93 Q38.1 ; C3406.1 116.85,80.58 116.93,80.65 v2(116.93,80.7) ; C78.2 v2(24.27,33.71) ; v2(85.67,41.88) 85.22,42.33 Q21.1 ; C202.2 57.16,22.17 57.04,22.29 v2(57.04,22.31) ; v2(85.67,43.26) 85.75,43.34 86.52,43.34 86.9,43.72 C3C9.2 ; D2748.2 12.65,68.42 v2(12.36,68.71) ; Y4102.2 v2(115.54,80) ; v2(15.68,66.06) 15.42,65.81 D2743.2 ; C354.2 38.58,37.36 v2(38.39,37.36) ; C3C8.2 86.72,39.64 86.46,39.38 v2(85.66,39.38) 85.64,39.41 85.63,39.41 Q20.1 ; Y4102.4 112.75,81.09 v2(112.43,80.77) ; v2(52.47,63.69) 52.47,62.55 C319.2 ; v2(59.3,68.13) 59.3,67.65 59.56,67.39 Q25.1 ; Q37.1 186.32,44.98 186.19,44.85 v2(185.9,44.85) ; Q36.1 188.03,42.32 187.58,41.88 v2(187.38,41.88) ; C239.2 83.07,54.67 v2(83.46,54.29) ; C1045.1 15.51,66.76 v2(15.17,66.42) ; RT854.2 95.39,62.91 95.6,62.7 v2(95.6,62.37) ; C187.2 66.94,16.41 66.96,16.4 R1012.2 ; C187.2 C1011.2 ; C187.2 67.24,17.08 67.55,17.39 v2(67.55,17.62) ; v2(77.92,23.28) 77.89,23.28 77.79,23.39 C267.2 ; 126.45,25.59 126.33,25.59 125.72,26.21 v1(125.72,26.88) ; R27306.2 R27305.2 19.44,59.54 18.64,58.74 v2(18.43,58.74) ; v1(136.92,51.19) 137.52,51.79 R3810.2 137.92,51.79 138.12,51.98 C393.2 ; C241.2 v4(86.48,38.64) 86.38,38.75 v2(85.66,38.75) ; v2(79.45,12.22) 79.53,12.29 R91353.2 ; R3809.2 138.2,48.53 138.4,48.73 R3803.2 138.14,49.28 137.81,48.96 137.18,48.96 v1(136.9,48.68) ; Q26.1 v2(55.4,68.06) ; C177.2 34.83,68.59 v2(35.11,68.87) ; R91321.2 R91322.2 107.51,23.25 v2(107.54,23.28) ; v2(46.37,70.42) 46.37,69.45 46.69,69.14 Q1002.1 ; C1035.2 v2(68.37,16.79) ; v2(39.53,37.36) 39.72,37.36 C256.2 ; v1(139.11,45.02) 138.6,44.51 C4524.2 ; v1(143.65,23.69) C112.2 ; C1000.2 v2(186.75,35.96) ; v2(100.75,26.48) U6581.4 ; v2(102.13,26.48) 102.13,24.95 102.56,24.52 U6581.2 ; C71.2 v2(16.78,33.37) ; Q24.1 62.2,67.8 61.94,68.06 v2(61.31,68.06) ; C158.2 15.71,26.04 v2(15.39,25.72) ; D25.2 v2(10.04,74.97) ; v2(89.61,15.53) 89.61,14.73 89.46,14.59 Q17.1 ; Q27.1 v2(57.68,68.05)
  TOP w0.508: v1(139,33.89) 139.47,34.35 C4526.2 ; C362.2 160.54,73.31 160.79,73.56 v2(160.79,73.7) ; SW1.2 v2(6.1,5.4) ; C4523.2 153.76,35.49 v1(154.1,35.84) ; C233.2 v2(177.64,36.72) ; C4531.2 143.74,36.76 v1(143.95,36.56) ; C363.2 182.51,45.17 v2(183.03,45.17) ; v2(70.45,64.86) 71.02,65.43 C242.2 ; v2(68.37,13.27) 68.56,13.08 C28024.2 ; C4824.2 112.81,32.28 v1(113.23,31.86) 112.27,30.89 C4813.2 ; C230.2 178.02,58.71 v2(178.02,59.06) ; v2(40.02,46.8) 40.02,46.45 C248.2 ; C4830.2 v1(93.9,34.1) ; C277.2 v2(160.05,55.77) ; C4831.2 104.17,26.48 v2(103.65,26.48) ; v1(147.62,37.64) 147.44,37.47 C4503.2 ; C379.2 v2(177.68,37.92) ; v1(102.05,39.48) 101.94,39.6 C4528.2 ; C27104.2 183.59,50.56 v2(182.9,49.87) ; C4833.2 94.98,27.33 94.89,27.24 v2(94.86,27.24) ; v2(20.36,55.35) 20.36,55.64 19.74,56.27 C98.2 ; C231.2 v2(176.92,51.07)
  BOTTOM w0.114: v2(101.73,57.28) 101.73,57.29 R11112.2
  BOTTOM w0.178: U7.9 30.92,57.93 v2(30.12,58.74) ; U7.10 31.16,58.33 30.76,58.73 v2(30.76,58.76) 30.98,58.76 31.01,58.73 U7.11
  BOTTOM w0.203: C113.2 152.83,27.57 152.8,27.55 C121.2 152.52,28.49 v1(152.44,28.56) ; R109.2 34.59,28.27 v2(34.72,28.4) ; C102.1 36.08,26.39 35.73,26.73 v2(35.52,26.73) R120.2 ; C8.2 133.92,64.8 v1(134.28,64.44) ; C28019.2 27.07,25.94 27.28,26.15 C28018.2 v2(27.28,27.11) ; C46.2 106.71,65.84 R22.2 ; v2(29.51,59.73) 29.85,60.07 C165.2 C167.2 ; C13.2 106.33,58.22 v2(106.13,58.01) 106.13,58.01 R402.2 ; C127.2 153.69,20.54 153.89,20.34 v1(153.89,19.95) 154.12,19.95 154.32,19.75 154.32,19.03 C123.2 ; R294.2 62.68,36.95 v2(62.86,36.77) ; v2(93.13,43.39) 93.11,43.39 92.57,43.93 R368.2 ; C313.2 99.58,59.35 100.21,59.35 100.47,59.61 100.65,59.61 100.89,59.86 C310.2 101.26,59.86 101.42,59.7 v2(101.66,59.7) ; R11120.2 96.1,58.09 95.87,58.32 95.55,58.32 v2(95.52,58.35) ; C252.2 34.71,69.12 34.96,68.87 v2(35.11,68.87) ; R221.2 9.81,69.2 v2(9.97,69.04) ; v2(11.84,66.6) 11.84,66.75 D8.3 D8.8 10.67,67.92 v2(10.27,67.92) ; C42.2 v2(115.29,68.24) 115.31,68.24 115.72,67.83 C210.2 115.34,67.43 v2(115.29,67.43) ; v2(99.21,63.18) 99.62,63.59 R355.2 ; v2(29.51,58.75) 29.51,59.08 29.76,59.33 C166.2 ; C503.2 135.08,69.5 R147.2 R146.2 ; C148.2 159.99,25.92 v2(161.13,27.06) ; C12.1 106.64,60.48 v2(106.64,61.63) ; v2(35.16,65.75) 35.1,65.81 R91348.1 34.87,66.67 34.71,66.83 C263.2 ; v2(36.81,70.46) 36.49,70.14 R91347.1 ; v2(126.09,69.51) 126.17,69.43 C9.2 126.17,68.29 126.13,68.25 v2(126.13,68.14) ; R23.2 105.83,68.2 105.33,68.2 v1(104.92,68.61) ; v1(128.45,67.16) 128.46,67.15 C184.2 ; C50.2 166.71,20.37 v1(166.52,20.56) ; v2(41.04,59.02) C28010.2 ; v1(165.38,25.98) 165.09,26.27 164.43,26.27 163.15,24.99 162.92,24.99 C60.2 ; C53.2 166.99,18.85 166.86,18.72 v1(166.86,18.53) ; R474.2 37.55,51.21 v2(37.81,51.46) ; v2(57.04,22.31) 57.04,22.09 56.7,21.75 R1001.2 ; v2(104.03,74.11) 104.43,74.11 104.67,73.87 R596.2 R595.2 ; C117.2 149.29,23.2 v1(149.42,23.07) ; C57.2 115.38,58.42 115.73,58.77 v2(115.83,58.77) ; C407.2 187.84,79.78 188.26,80.2 C28004.2 ; v2(61.51,21.91) 61.64,21.91 61.99,21.55 61.99,21.01 61.97,20.99 C1028.2 ; v2(24.13,28.31) 24.05,28.23 C28017.2 ; v2(12.08,34) 12.24,34 12.48,34.24 D12.2 ; C66.2 67.58,44.06 v2(67.45,43.94) ; C179.2 131.71,68.6 131.71,69.1 v2(131.73,69.12) ; R220.2 8.35,69.33 v2(8.08,69.06) ; C119.2 156.11,20.24 156.16,20.19 156.16,19.25 v1(156.67,18.74) ; R64.2 166.69,25.55 166.59,25.65 v1(166.57,25.65) ; v2(180.68,54.64) 180.48,54.84 180.48,56.5 180.64,56.67 R265.2 ; v2(113.13,67.53) 113.12,67.52 C206.2 ; C178.2 129.6,66.99 v1(129.77,67.16) ; R200.2 51.07,59.14 v2(51.02,59.08) ; v2(30.2,26.72) C28020.2 ; 35.9,28.36 v2(35.36,28.36) ; 35.9,28.36 U16.1 ; 35.9,28.36 35.9,28.54 36.06,28.7 36.25,28.7 36.39,28.56 U16.2 ; v2(70.45,64.86) 70.6,64.86 C18.1 R40.2 C19.1 ; C111.2 149.58,25 v1(149.47,25.11) ; C43.2 113.13,68.82 v2(113.13,68.19)
  BOTTOM w0.254: C491.2 100.97,50.99 99.72,50.99 99.07,51.64 v2(99.07,51.74) 99.47,51.74 99.82,52.08 ; v1(155.09,28.56) 155.09,28.18 155.3,27.96 C124.1 ; R6D82.2 99.38,73.74 v2(99.38,73.22) ; v2(163.59,31.3) 163.72,31.18 C28015.1 ; J23.18 50.25,62.45 49.75,62.95 v2(49.75,63.21) ; v2(32.23,19.87) 32.33,19.77 32.33,19.47 32.54,19.25 U4100.20 ; U4100.32 35.85,24.99 v2(35.94,25.08) ; C207.2 115.79,65.29 v2(115.79,65.3) ; C28021.1 186.14,48.9 185.84,48.6 185.84,48.19 v2(186.41,47.62) ; U4100.35 37.35,24.94 v2(37.21,25.08) ; C315.2 56.29,59.23 56.12,59.4 C316.2 56.12,60.33 v2(56.3,60.51) ; v2(98.57,58.81) 98.77,58.62 R305.2 ; v2(80.41,64.88) 80.42,64.8 81.63,63.8 ; J15.57 82.77,76.45 v2(82.4,76.82) ; J23.40 61.25,62.28 v2(60.88,62.65) ; C90.2 169.72,75.25 169.97,74.99 v2(169.97,74.23) 170.06,74.14 U15.1 ; C67.2 65.32,44 v2(65.3,43.98) ; v2(48.41,63.05) 48.75,62.71 J23.15 ; C487.2 102.48,50.6 v2(101.84,49.96) ; C28016.1 171.32,28.25 v2(171.16,28.08) ; J15.14 80.02,64.45 v2(80,64.45) ; U4100.A31 43.77,23.4 v2(43.82,23.45) ; J23.21 51.75,62.43 50.89,63.28 v2(50.82,63.28) ; v1(157.62,25.62) 157.36,25.88 C115.2 ; C48.2 104.45,52.6 v1(104.53,52.69) ; v1(157.6,22.39) 156.98,23.01 C155.1 ; U4100.A26 v2(34.32,23.4) ; C486.1 103.49,50.3 v2(103.15,49.96) ; v3(172.61,74.04) 172.61,71.56 171.47,70.42 C89.2 ; J15.60 89.71,71.41 v2(89.76,71.25) 89.73,71.24 89.71,71.22 89.7,71.22 89.69,71.2 89.32,71.1 89.17,71.18 88.31,71.9 ; J18.3 161.15,23.59 v2(161.19,23.63)
  BOTTOM w0.305: v2(34.25,17.33) 34.67,17.75 U4100.A15 ; J12.1 v2(194.58,60.15) ; J13.1 v2(192.41,46.65) ; U4100.23 v2(32.24,20.75) ; v2(52.47,63.69) 53.75,62.41 J23.25 ; J13.19 v2(192.33,37.65) ; v2(192.38,40.74) 192.73,40.74 192.82,40.65 J13.13 ; U4100.62 v2(45.65,16.75) ; v2(192.33,36.25) 192.7,36.25 192.8,36.15 J13.22 ; U4100.41 v2(40.35,25.06) ; J13.28 192.74,33.15 192.53,33.36 v2(192.33,33.36) ; U4100.71 45.33,12.25 45.52,12.06 v2(45.72,12.06) ; J12.12 191.26,54.65 191.09,54.82 v2(190.66,54.82) ; v2(192.33,31.57) 192.41,31.65 J13.31 ; U4100.98 v2(33.6,24.74) ; v2(192.33,34.44) 192.53,34.44 192.74,34.65 J13.25 ; J23.2 42.25,62.33 41.98,62.6 40.53,62.6 v2(40.4,62.47) ; v2(32.24,22.25) U4100.26 ; v1(124.2,66.09) 124.29,66 C1.2 ; J13.7 v2(192.41,43.65) ; U4100.68 45.63,13.75 v2(45.72,13.84) ; v2(34.3,18.63) 34.3,18.15 33.9,17.75 U4100.17 ; J23.12 47.25,60.77 47.31,60.71 47.31,60.16 46.65,59.5 v2(46.25,59.5) ; v2(46.38,63.65) 46.38,63.07 45.75,62.44 J23.9 45.75,60.88 45.51,60.64 v2(45.51,60.51) ; v2(34.41,13.75) U4100.A7 ; v2(124.96,64.51) 125.05,64.42 C59.2 ; U4100.6 v2(34.18,12.25) ; J23.5 43.75,62.55 42.24,64.06 v2(41.26,64.06) ; v2(45.52,24) U4100.99 ; U4100.38 v2(38.85,25.05) ; U4100.107 41.85,13.75 U4100.A50 ; J13.38 v2(192.41,28.15) ; J13.10 v2(192.4,42.15) ; J13.4 v2(192.39,45.15) ; v2(192.38,38.94) 192.47,38.94 192.69,39.15 J13.16 ; J12.15 v2(191.39,53.15)
  BOTTOM w0.381: C342.1 119.68,65.98 v2(119.68,65.3) ; v2(115.83,66.03) 115.83,66.53 C41.2 ; v1(125.72,66.09) 126.12,65.69 C58.2 ; C334.1 118.07,65.33 v2(118.1,65.3) ; J12.21 v2(195.67,61.9) ; v2(172.42,31.3) 171.92,31.81 U42.3 ; C191.2 125.01,66.86 v2(125.01,67.65) ; v2(148.45,17.55) 148.45,18.53 J17.31 ; C338.1 121.22,65.95 v2(121.22,65.28) ; C349.1 132.14,79.19 v2(131.59,79.19) ; C61.2 v2(168.16,18.6) ; C196.2 132.41,68.1 132.4,68.12 132.36,68.12 v2(132.35,68.13) ; v2(188.27,78.03) 187.84,78.46 C407.2 ; C359.1 117.05,68.24 v2(117.1,68.19) ; C1012.2 61.79,22.19 v2(61.51,21.91) ; v2(34.56,65.75) 34.56,65.95 33.77,66.74 D2745.2 ; v2(33.65,70.48) 33.42,70.25 D2746.2 ; v1(162.04,19.64) 162.04,19.83 162.39,20.18 163.05,20.18 163.48,19.75 J18.7 ; v1(131.09,67.16) 131.02,67.09 C504.2 ; v2(23.01,17.21) 23.01,17.33 22.61,17.72 J4.6 ; v2(127.79,64.44) 127.5,64.73 C195.1 126.7,64.73 v2(126.48,64.51) ; J14.1 104.6,17.24 104.17,16.81 v2(104.17,16.61) ; v2(67.55,17.62) 67.55,17.39 67.24,17.08 C200.2 ; J24.6 190.13,78.1 v2(190.06,78.03) ; Q14.1 96.47,21.84 v2(97.08,22.45) D2744.2 ; R442.2 67.46,57.34 v2(67.07,57.72) ; Q5.1 173.09,18.93 v2(172.6,19.42) ; C180.2 133.6,66.47 134.03,66.47 134.31,66.75 v2(134.69,66.75) ; v2(180.68,54.64) 181.15,54.64 C232.1 ; v2(103.5,16.66) 103.13,16.66 102.6,17.2 J14.2 ; v2(65.95,47.43) 65.68,47.7 C64.2 ; C190.1 130.76,64.8 v2(130.43,64.47) ; v4(60.09,18.22) 59.72,17.85 C1017.2 ; C355.1 124.05,67.54 v2(123.96,67.63) 124.3,67.98 C346.1 ; C20.2 v2(174.55,20.97) ; v2(135.77,69.34) 135.61,69.5 C503.2 ; C347.1 133.91,77.95 v2(133.83,78.04) ; v3(58.08,10.45) 57.05,10.45 56.78,10.71 C1010.2 56.47,11.11 56.16,10.81 C1009.2 55.39,10.81 55.14,11.07 55.14,12.95 55.55,13.37 C1007.2 56.56,14.16 C1008.2 R227.2 ; v2(178.96,31.13) 178.96,30.73 178.66,30.43 178.14,30.43 177.65,29.95 U11.4 ; C28002.1 v2(62.86,36.77) ; J18.8 157.55,19.37 156.92,18.74 v1(156.67,18.74) ; v2(49.42,53.86) R242.2
  BOTTOM w0.406: v2(88.56,75.12) 88.44,75.25 87.45,75.25 J15.64 85.78,73.33 v2(85.78,73.33) 85.76,73.3 85.76,73.3 J15.63 J15.62 J15.61
  BOTTOM w0.508: CN2.5 79.07,14.55 78.66,14.96 v2(78.66,15.47) ; v2(69.17,49.73) 69.76,49.73 C65.2 ; J4.5 v2(31.42,15.59) ; v3(58.44,15.64) 58.44,15.63 58.78,15.29 C1015.2 ; CN2.6 70.61,14.55 v2(68.37,16.79) ; v2(39.9,68.74) 39.6,68.45 J23.41 ; U41.3 166.44,32.13 166.68,32.37 v3(166.68,32.91) ; J14.9 v2(106.67,12.72) ; v2(61.31,68.06) 62.12,67.25 J23.42 ; J25.32 117.62,15.6 117.15,16.07 v2(116.01,16.07) ; v1(148.56,15.92) 148.14,15.5 J25.31 ; J24.7 v2(194.2,83.4) ; J13.51 v2(195.04,47.95) ; J3.7 183.04,26.6 v2(182.97,26.54) ; J17.32 119.79,19.29 v2(118.63,19.29) ; v2(86.24,12.53) 86.44,12.72 J14.10 ; J24.8 v2(194.26,76.8)
  vias: v1(98.15,39.64) v1(100.73,32.61) v1(100.77,38.25) v1(100.77,36.35) v1(109.83,47.07) v1(110.25,45.71) v1(111.43,46.89) v1(112.11,49.77) v1(112.08,45.58) v1(113.03,47.87) v1(113.34,46.77) v1(114.15,47.56) v1(114.52,46.34) v1(116.3,47.31) v1(116.58,32.36) v1(117.19,48.83) v1(117.28,47.23) v1(117.43,34.16) v1(117.52,44.97) v1(118.43,48.22) v1(120.29,45.16) v1(120.41,46.75) v1(121.25,47.62) v1(121.29,44.92) v1(121.25,34.13) v1(121.36,37.57) v1(122.79,47.92) v1(122.79,46.21) v1(123.74,48.12) v1(123.74,47.05) v1(124.3,45.64) v1(124.33,44.03) v1(125.24,48.47) v1(125.24,46.87) v1(126.37,47.94) v1(126.37,45.96) v1(127.32,48.42) v1(127.32,46.82) v1(128.45,47.59) v1(128.45,45.23) v1(129.58,47.33) v1(129.58,45.73) v1(130.3,34.23) v1(130.7,47.51) v1(131.98,48.56) v1(132.7,32.97) v1(133.25,33.97) v1(134.91,32.33) v1(135.2,58.78) v1(135.48,62.52) v1(135.68,52.34) v1(135.74,34.36) v1(136.72,58.16) v1(137.03,59.75) v1(137.08,62.52) v1(137.31,61.56) v1(137.64,34.29) v1(137.74,55.64) v1(138.64,62.25) v1(138.7,59.25) v1(139.08,54.29) v1(139.85,58.05) v1(139.82,53.51) v1(140.04,60.85) v1(151.02,30.03) v1(151.27,42.57) v1(151.55,30.03) v1(152.8,43.14) v1(155.85,16.27) v1(156.38,16.27) v2(4.32,47.81) v2(7.45,74.61) v2(8.22,73.05) v2(11.7,70.17) v2(15.18,58.55) v2(15.21,57.2) v2(15.52,70.64) v2(16.32,29.47) v2(17.81,53.19) v2(17.95,57.05) v2(18.38,29.45) v2(18.61,17.26) v2(18.81,24.06) v2(18.81,22.67) v2(18.81,21.4) v2(19.37,54.75) v2(19.39,29.45) v2(20.21,24.06) v2(20.21,22.67) v2(20.21,21.4) v2(21.48,24.06) v2(21.48,22.67) v2(22.54,57.43) v2(22.88,59.75) v2(23.01,14.67) v2(23.01,13.27) v2(23.01,12) v2(23.39,60.26) v2(23.53,28.33) v2(23.89,60.77) v2(23.89,59.75) v2(24.28,14.67) v2(24.28,13.27) v2(24.28,12) v2(24.4,62.8) v2(25.67,14.67) v2(25.67,13.27) v2(25.67,12) v2(26.01,18.99) v2(26.31,61.8) v2(26.61,18.99) v2(27.51,65.37) v2(27.51,64.22) v2(27.54,62.99) v2(27.6,61.96) v2(31.4,65.64) v2(31.4,64.98) v2(31.4,64.32) v2(31.4,63.66) v2(31.4,62.89) v2(31.4,62.23) v2(32.23,65.64) v2(32.23,64.98) v2(32.23,64.32) v2(32.23,63.66) v2(32.23,62.89) v2(32.23,62.23) v2(35.57,39.5) v2(35.71,64.46) v2(35.67,63.37) v2(35.71,62.3) v2(35.69,61.15) v2(36.17,39.5) v2(36.32,22.29) v2(36.32,21.14) v2(36.32,19.24) v2(36.32,18.1) v2(36.32,16.06) v2(36.32,14.92) v2(36.32,12.76) v2(36.32,11.62) v2(37.05,51.46) v2(37.3,27.11) v2(37.34,22.29) v2(37.34,21.14) v2(37.34,19.24) v2(37.34,18.1) v2(37.34,16.06) v2(37.34,14.92) v2(37.34,12.76) v2(37.34,11.62) v2(37.99,60.64) v2(38.6,69.7) v2(38.56,68.74) v2(38.63,58.99) v2(38.57,51.46) v2(38.61,22.29) v2(38.61,21.14) v2(38.61,19.24) v2(38.61,18.1) v2(38.61,16.06) v2(38.61,14.92) v2(38.61,12.76) v2(38.61,11.62) v2(38.7,26.99) v2(39.18,69.16) v2(39.29,61.83) v2(39.5,22.29) v2(39.5,21.14) v2(39.63,19.24) v2(39.63,18.1) v2(39.63,16.06) v2(39.63,14.92) v2(39.63,12.76) v2(39.63,11.75) v2(39.83,69.7) v2(40.35,26.99) v2(40.51,22.29) v2(40.51,21.14) v2(40.64,19.24) v2(40.64,18.1) v2(40.64,16.06) v2(40.64,14.92) v2(40.64,12.76) v2(40.64,11.75) v2(41.29,71.66) v2(41.51,22.29) v2(41.51,21.14) v2(41.51,19.24) v2(41.51,18.1) v2(41.51,14.92) v2(41.46,12.76) v2(41.46,11.75) v2(43.15,71.66) v2(44.42,70.61) v2(47.67,53.1) v2(48.19,66.07) v2(48.28,70.42) v2(48.25,53.1) v2(48.84,53.09) v2(49.52,53.09) v2(50,66.07) v2(50,59.08) v2(50,58.07) v2(50.18,53.09) v2(50.51,58.57) v2(51.02,58.07) v2(51.38,53.09) v2(51.96,53.09) v2(52.47,68.01) v2(52.57,53.09) v2(53.15,53.09) v2(55.51,38.05) v2(55.59,39.81) v2(56.1,38.05) v2(56.71,38.03) v2(58.64,36.94) v2(58.64,35.87) v2(59.27,36.43) v2(59.91,36.91) v2(59.91,35.87) v2(71.42,34.15) v2(71.43,33.06) v2(71.43,31.97) v2(72.02,34.15) v2(72.02,33.06) v2(72.02,31.97) v2(72.56,50.73) v2(73.14,50.73) v2(73.73,50.73) v2(73.75,26.32) v2(73.75,24.56) v2(74.31,50.73) v2(74.26,25.43) v2(74.77,26.32) v2(74.77,24.56) v2(75.24,19.53) v2(75.84,37.29) v2(76.43,37.29) v2(77.39,60.26) v2(78,60.26) v2(79.04,60.34) v2(79.04,59.75) v2(80.2,38.01) v2(80.79,39.22) v2(81.21,76.82) v2(81.81,76.82) v2(81.78,25.63) v2(81.88,36.82) v2(83.63,15.45) v2(102.38,74.64) v2(111.42,19.18) v2(130.29,78.6) v2(131.56,76.83) v2(133.83,76.17) v2(136.92,70.39) v2(138.37,70.37) v2(138.45,69.25) v2(138.87,72.54) v2(139.2,84.6) v2(139.46,84) v2(139.85,84.59) v2(139.94,70.89) v2(140.48,84.59) v2(140.56,62.55) v2(140.78,70.12) v2(140.81,53.48) v2(141.12,84.59) v2(141.24,84) v2(141.22,70.55) v2(141.65,73.77) v2(141.75,84.59) v2(141.85,84) v2(142.39,84.59) v2(142.46,84) v2(143.02,84.59) v2(143.1,84) v2(143.66,84.59) v2(143.68,84) v2(161.51,75.93) v2(161.92,69.68) v2(162.25,76.11) v2(162.83,76.11) v2(170.45,28.08) v2(170.45,27.32) v2(171.16,27.32) v2(171.98,28.08) v2(171.98,27.32) v2(173.88,63.82) v2(175.25,63.89) v2(175.25,63.26) v2(175.76,63.56) v2(178.65,54.64) v2(178.65,53.62) v2(178.65,52.6) v2(179.67,54.64) v2(179.67,53.62) v2(179.67,52.6) v2(180.68,53.62) v2(180.68,52.6) v2(181.32,41.17) v2(181.32,40.16) v2(181.83,40.67) v2(181.96,27.91) v2(182.33,41.17) v2(182.33,40.16) v2(182.25,29.12) v2(186.44,54.75) v2(186.39,46.36) v2(187.38,45.48) v2(187.38,43.7) v2(189.73,39.32) v2(189.72,37.57) v2(189.73,35.76) v2(191.83,52.32) v2(195.03,20.85) v2(195.11,49.01) v3(1.05,79.42) v3(1.02,77.09) v3(1.02,75.18) v3(1.02,73.28) v3(1.02,71.37) v3(1.97,80.64) v3(1.99,68.3) v3(2.27,30.1) v3(2.27,28.19) v3(2.27,26.29) v3(2.27,24.38) v3(2.27,22.48) v3(2.27,20.57) v3(2.27,12.68) v3(2.27,10.77) v3(2.27,8.87) v3(2.73,13.84) v3(3.41,67.56) v3(3.6,65.9) v3(3.76,1.97) v3(3.87,80.64) v3(4.02,33.83) v3(4.02,13.84) v3(5.15,18.18) v3(5.27,16.28) v3(5.41,1.02) v3(5.78,80.64) v3(6.97,49.03) v3(7.31,1.02) v3(7.36,64.57) v3(7.68,80.64) v3(7.74,2.87) v3(8.17,4.7) v3(8.55,6.5) v3(8.76,48.71) v3(9.21,65.03) v3(9.58,80.57) v3(9.97,7.86) v3(10.43,48.98) v3(10.56,64.45) v3(10.86,51.88) v3(11.31,79.75) v3(12.46,78.24) v3(12.78,76.36) v3(13.12,74.42) v3(14.94,73.56) v3(16.85,73.56) v3(17.8,72.38) v3(19.5,7.87) v3(21.4,7.87) v3(22.92,6.71) v3(24.82,6.62) v3(25.42,72.38) v3(26.73,6.62) v3(27.32,72.38) v3(28.63,6.62) v3(29.23,72.38) v3(30.54,6.62) v3(31.13,72.38) v3(32.44,6.62) v3(33.04,72.38) v3(34.35,6.62) v3(34.94,72.38) v3(36.25,6.62) v3(36.79,72.85) v3(38.16,6.62) v3(38.62,73.38) v3(39.33,40.13) v3(39.71,40.82) v3(39.71,39.45) v3(40.12,40.13) v3(40.06,6.62) v3(40.3,31.7) v3(40.3,30.96) v3(40.28,30.21) v3(40.52,73.38) v3(40.5,40.82) v3(40.5,39.45) v3(40.63,29.55) v3(40.91,40.13) v3(41.01,30.19) v3(41.08,31.7) v3(41.08,30.96) v3(41.29,40.82) v3(41.29,39.45) v3(41.42,29.55) v3(41.75,40.11) v3(41.8,30.21) v3(41.87,31.7) v3(41.87,30.96) v3(41.97,6.62) v3(42.18,39.46) v3(42.43,73.38) v3(42.94,39.46) v3(43.71,39.46) v3(43.73,31.48) v3(43.73,30.67) v3(43.73,29.93) v3(43.87,6.62) v3(44.33,73.38) v3(44.39,30.31) v3(44.47,39.46) v3(44.47,31.48) v3(44.9,30.88) v3(45.23,39.46) v3(45.35,31.47) v3(45.78,6.62) v3(46.24,73.38) v3(46.92,18.15) v3(46.94,17.41) v3(46.92,16.67) v3(46.92,15.93) v3(47.67,18.15) v3(47.68,17.41) v3(47.67,16.66) v3(47.67,15.92) v3(47.68,6.62) v3(48.14,73.38) v3(49.59,6.62) v3(50.05,73.38) v3(51.49,6.62) v3(51.95,73.38) v3(53.19,35.07) v3(53.35,39.79) v3(53.4,6.62) v3(53.57,34.4) v3(53.86,73.38) v3(53.95,35.07) v3(54.1,39.79) v3(54.2,23.4) v3(54.2,22.64) v3(54.27,41.3) v3(54.38,34.4) v3(54.71,35.07) v3(54.84,39.79) v3(54.96,23.4) v3(54.96,22.64) v3(55.05,41.3) v3(55.15,34.4) v3(55.3,6.62) v3(55.48,35.07) v3(55.72,23.4) v3(55.72,22.64) v3(55.76,73.38) v3(55.84,41.3) v3(55.88,34.4) v3(56.29,35.04) v3(56.48,23.4) v3(56.63,41.3) v3(56.67,34.4) v3(57.24,23.42) v3(57.21,6.62) v3(57.42,41.3) v3(57.67,73.38) v3(57.84,9.5) v3(57.84,8.73) v3(57.84,7.98) v3(58.2,41.3) v3(58.58,9.47) v3(58.58,8.74) v3(58.58,8) v3(58.76,6.6) v3(58.99,41.3) v3(59.57,73.38) v3(59.78,41.3) v3(61.48,73.38) v3(63.38,73.38) v3(65.29,73.38) v3(67.04,30.12) v3(67.19,73.55) v3(67.8,30.12) v3(68.56,30.12) v3(68.64,6.62) v3(68.7,74.71) v3(69.32,30.12) v3(69.41,76.48) v3(70.08,30.12) v3(70.54,6.62) v3(70.62,77.95) v3(71.83,79.42) v3(72.45,6.62) v3(73.04,80.89) v3(74.25,82.37) v3(74.35,6.62) v3(75.45,83.84) v3(75.67,16.14) v3(76.26,6.62) v3(76.45,16.14) v3(77.18,16.14) v3(78.16,6.62) v3(79.85,7.5) v3(80.33,9.34) v3(81.78,10.57) v3(83.69,10.62) v3(85.59,10.62) v3(86.69,88.38) v3(87.5,10.62) v3(88.09,88.35) v3(89.4,10.62) v3(90.5,88.38) v3(91.31,10.62) v3(92.41,88.38) v3(93.21,10.62) v3(94.31,88.38) v3(95.12,10.62) v3(96.22,88.38) v3(97.02,10.62) v3(98.12,88.38) v3(98.93,10.62) v3(100.03,88.38) v3(100.83,10.62) v3(101.93,88.38) v3(102.74,10.62) v3(103.84,88.38) v3(104.64,10.62) v3(105.74,88.38) v3(106.55,10.62) v3(107.65,88.38) v3(108.45,10.62) v3(109.55,88.38) v3(110.36,10.62) v3(111.46,88.38) v3(112.26,10.62) v3(113.36,88.38) v3(114.17,10.62) v3(115.27,88.38) v3(116.18,10.6) v3(117.17,88.38) v3(117.98,10.62) v3(119.08,88.38) v3(119.88,10.62) v3(120.98,88.38) v3(121.79,10.62) v3(122.89,88.38) v3(123.69,10.62) v3(124.79,88.38) v3(125.6,10.62) v3(126.7,88.38) v3(127.5,10.62) v3(128.6,88.38) v3(129.41,10.62) v3(130.51,88.38) v3(131.31,10.62) v3(132.41,88.38) v3(133.22,10.62) v3(134.32,88.38) v3(135.12,10.62) v3(136.22,88.38) v3(137.03,10.62) v3(138.13,88.38) v3(139.29,10.43) v3(139.62,54.67) v3(140.03,88.38) v3(140.79,10.44) v3(141.94,88.38) v3(142,69.56) v3(142.69,10.44) v3(143.4,69.53) v3(143.84,88.38) v3(144.16,69.53) v3(144.6,10.44) v3(144.93,69.53) v3(145.75,88.38) v3(146.5,10.44) v3(146.58,70.06) v3(147.47,70.06) v3(147.65,88.38) v3(148.41,10.44) v3(148.48,70.06) v3(149.56,88.38) v3(150.33,82.79) v3(150.31,10.44) v3(150.89,70.04) v3(151.12,82.79) v3(151.46,88.38) v3(151.66,70.04) v3(152.01,82.79) v3(152.27,10.44) v3(152.8,82.79) v3(153.37,88.38) v3(153.51,73.14) v3(153.51,71.85) v3(153.89,72.49) v3(154.17,10.44) v3(154.32,73.16) v3(154.29,71.85) v3(154.67,72.49) v3(155.08,71.85) v3(155.27,88.38) v3(155.46,72.49) v3(155.87,71.85) v3(156.08,10.44) v3(156.25,72.49) v3(156.65,71.85) v3(157.04,72.49) v3(157.18,88.38) v3(157.98,10.62) v3(159.08,88.38) v3(159.89,10.62) v3(160.99,88.38) v3(161.79,10.62) v3(162.75,48.44) v3(162.89,88.38) v3(162.96,49.16) v3(163.7,10.62) v3(163.87,32.92) v3(164.5,47.65) v3(164.5,46.89) v3(164.66,32.92) v3(164.8,88.38) v3(165.27,47.65) v3(165.27,46.89) v3(165.44,32.92) v3(165.6,10.62) v3(166.03,47.65) v3(166.03,46.89) v3(166.54,74.33) v3(166.7,88.38) v3(166.92,75.02) v3(167.28,74.33) v3(167.42,32.92) v3(167.51,10.62) v3(168.17,46.52) v3(168.19,32.92) v3(168.48,47.2) v3(168.61,88.38) v3(168.93,46.54) v3(168.95,32.91) v3(169.31,50.35) v3(169.39,47.24) v3(169.41,10.62) v3(169.47,48.1) v3(169.65,49.58) v3(169.74,46.54) v3(169.72,33.32) v3(169.76,36.35) v3(170.07,48.83) v3(170.2,50.35) v3(170.33,48.1) v3(170.33,47.22) v3(170.51,88.38) v3(170.47,49.56) v3(170.55,36.35) v3(170.45,33.32) v3(170.71,46.52) v3(170.83,48.83) v3(171.09,50.35) v3(171.23,33.32) v3(171.26,48.06) v3(171.28,47.18) v3(171.32,10.62) v3(171.39,74.04) v3(171.36,49.53) v3(171.7,46.5) v3(171.85,50.35) v3(171.98,48.96) v3(172.17,48.04) v3(172.17,47.18) v3(172.42,88.38) v3(172.48,49.83) v3(172.64,46.46) v3(172.99,48.96) v3(173.07,48.11) v3(173.07,47.18) v3(173.22,10.62) v3(173.5,46.04) v3(173.88,48.7) v3(173.91,47.78) v3(173.88,46.8) v3(174.32,88.38) v3(174.26,74.05) v3(174.26,45.81) v3(174.5,47.25) v3(174.78,46.49) v3(174.88,47.97) v3(175.13,10.62) v3(175.15,74.05) v3(175.28,45.88) v3(175.42,47.24) v3(175.46,48.61) v3(175.81,88.33) v3(175.76,46.46) v3(175.93,47.89) v3(176.04,74.05) v3(176.29,45.91) v3(176.43,48.61) v3(176.36,47.2) v3(176.76,46.5) v3(176.93,74.05) v3(176.88,47.92) v3(177.03,10.62) v3(177.18,45.78) v3(177.38,47.17) v3(177.82,74.05) v3(177.79,46.51) v3(178.94,10.62) v3(179.43,88.33) v3(189.69,88.38) v3(189.72,10.6) v3(191.47,88.38) v3(193.37,88.38) v3(194.47,10.6) v3(195.28,88.38) v3(196.08,10.62) v3(197.18,88.37) v3(197.18,86.47) v3(197.18,84.56) v3(197.18,82.66) v3(197.18,80.75) v3(197.18,78.85) v3(197.18,76.94) v3(197.18,75.04) v3(197.18,73.13) v3(197.18,71.23) v3(197.18,69.32) v3(197.18,67.42) v3(197.18,65.51) v3(197.18,63.61) v3(197.18,61.7) v3(197.18,59.8) v3(197.2,57.53) v3(197.18,55.99) v3(197.18,54.08) v3(197.18,52.18) v3(197.18,50.27) v3(197.18,48.37) v3(197.18,46.46) v3(197.18,44.56) v3(197.18,42.65) v3(197.18,40.75) v3(197.18,38.84) v3(197.18,36.94) v3(197.18,35.03) v3(197.18,33.13) v3(197.18,31.22) v3(197.18,29.32) v3(197.18,27.41) v3(197.18,25.51) v3(197.18,23.6) v3(197.18,21.7) v3(197.18,15.98) v3(197.18,14.08) v3(197.18,12.17) v4(13.37,60.89) v4(13.37,60.25) v4(14.01,60.89) v4(14.01,60.25) v4(19.14,39.84) v4(19.14,38.82) v4(19.14,37.81) v4(20.14,39.84) v4(20.14,38.82) v4(20.14,37.81) v4(21.15,39.84) v4(21.15,38.82) v4(21.15,37.81) v4(27.32,43.88) v4(27.32,43.24) v4(27.32,42.61) v4(27.32,41.97) v4(27.32,41.34) v4(27.32,40.7) v4(27.45,30.48) v4(27.45,29.84) v4(27.45,29.19) v4(27.65,34.73) v4(28.06,31.3) v4(28.06,30.67) v4(28.06,30.03) v4(28.06,29.4) v4(28.06,28.76) v4(31.95,66.38) v4(34.71,11.42) v4(39.13,20.28) v4(40.28,11.14) v4(42.36,29.75) v4(45.05,38.52) v4(45.89,29.98) v4(53.13,41.41) v4(59.12,60.95) v4(60.09,19.47) v4(60.65,18.98) v4(60.94,18.22) v4(61.03,16.62) v4(61.61,19.47) v4(61.69,16.62) v4(61.99,61.02) v4(62.5,18.2) v4(62.63,61.02) v4(63.01,60.26) v4(63.01,59.62) v4(63.01,58.99) v4(63.14,19.47) v4(63.26,61.02) v4(63.31,16.62) v4(63.65,60.26) v4(63.65,59.62) v4(63.65,58.99) v4(63.9,61.02) v4(66.01,30.36) v4(71.21,29.83) v4(71.67,31.25) v4(82.16,77.56) v4(91.56,39.91) v4(92.12,50.58) v4(93.16,74.92) v4(94.15,75.64) v4(95.21,75.64) v4(96.56,80.33) v4(97.2,80.33) v4(97.24,75.64) v4(98.19,80.33) v4(98.82,80.33) v4(99.84,80.33) v4(100.09,75.57) v4(100.48,80.33) v4(100.73,75.57) v4(101.69,79.18) v4(102.33,79.18) v4(102.63,80.33) v4(102.96,79.18) v4(108.3,50.73) v4(110.28,62.22) v4(111.85,42.81) v4(112.79,61.15) v4(113.28,81.16) v4(114.09,24.73) v4(114.45,61.15) v4(115.97,61.15) v4(117.49,61.15) v4(119.02,61.15) v4(120.54,61.15) v4(122.07,61.15) v4(123.61,61.1) v4(131.34,82.87) v4(132.35,82.87) v4(133.24,42.99) v4(133.5,82.87) v4(134.64,82.87) v4(135.43,44.56) v4(136.42,75.37) v4(136.42,74.74) v4(136.54,83.88) v4(137.05,75.37) v4(137.05,74.74) v4(137.43,83.81) v4(137.69,75.37) v4(137.69,74.74) v4(138.32,75.37) v4(138.32,74.74) v4(139.01,56.45) v4(139.85,26.99) v4(140.58,61.81) v4(143.05,70.98) v4(148.48,54.16) v4(148.53,53.53) v4(150.59,80.12) v4(151.22,30.64) v4(152.62,69.84) v4(152.7,71.13) v4(153.26,69.84) v4(153.89,69.84) v4(154.53,69.84) v4(155.03,34) v4(155.16,69.84) v4(155.8,69.84) v4(156.43,69.84) v4(157.07,69.84) v4(157.12,51.65) v4(157.7,69.84) v4(157.75,51.65) v4(160.88,77.61) v4(161.18,51.62) v4(161.18,50.99) v4(161.18,50.35) v4(162.5,54.39) v4(165.04,69.3) v4(165.02,67.45) v4(165.32,69.89) v4(165.27,68.41) v4(165.63,71.79) v4(165.68,69.3) v4(165.65,67.5) v4(167.12,46.8) v4(167.89,70.57) v4(170.5,34.83) v4(171.26,62.55) v4(173.55,49.69) v4(174.6,74.86) v4(174.95,39.99) v4(175.91,27.19) v4(177.61,54.24) v4(177.67,44.94)
