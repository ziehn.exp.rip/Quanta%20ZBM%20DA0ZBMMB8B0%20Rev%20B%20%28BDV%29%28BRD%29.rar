# Allegro board Quanta ZBM DA0ZBMMB8B0 Rev B BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_SEL_L: length 109.1
  TOP w0.079: U17.H6 v1(154.86,23.37)
  TOP w0.117: Q9.2 160.8,68.38 160.81,68.38 161.64,67.55 162.16,67.55 162.83,68.22 Q10.2 163.67,67.77 164.49,67.77 164.66,67.94 164.66,68.85 164.56,68.95 164.56,69.45 164.86,69.76 164.86,70.29 165.35,70.78 165.35,71.44 165.17,71.61 165.17,71.96 165.64,72.43 165.64,73.36 165.96,73.67 165.96,75.04 166.92,76.01 v4(167.4,76.01) 167.63,76.23 171.65,76.23 v2(171.9,75.98)
  IN1 w0.079: v1(154.86,23.37) 155.18,23.04 155.85,23.04 156.1,22.79
  IN1 w0.097: v2(171.9,75.98) 172.1,75.78 172.1,73.13 188.96,56.27 188.96,41.38 188.54,40.96 188.54,33.25 181.27,25.98 177.89,25.98 174.86,22.95 174.22,22.95 172.62,21.35 164.89,21.35 163.63,22.61 158.19,22.61 158.01,22.79 156.1,22.79
HP_GND_RING2: length 3.5
  TOP w0.203: 18.87,42.75 19.14,42.49 U3.8
  TOP w0.508: 18.87,42.75 18.46,43.17 v2(18.46,44.6)
HP_GND_SLEEVE: length 3.3
  TOP w0.203: 19.54,43.06 U3.7
  TOP w0.508: v2(19.22,44.64) 19.22,43.37 19.54,43.06
HP_INT_ODL: length 105.1
  TOP w0.089: U1JSL.CJ19 103.16,65.61 v2(102.83,65.94)
  TOP w0.109: R84.2 23.79,38.8 v2(23.67,38.92) 23.67,38.91 23.38,38.62 U3.35
  IN1 w0.097: v2(60.47,48.7) 60.47,46.91 59.49,45.93 48.38,45.93 45.18,49.13 37.04,49.13 35.84,47.94 31.11,47.94 28.34,45.17 28.34,40.5 27.93,40.09 26.46,40.09 25.42,39.05 23.79,39.05 v2(23.67,38.92)
  BOTTOM w0.114: v2(60.47,48.7) 61.46,47.72 62.66,47.72 63.01,48.06 63.01,50.23 64.92,52.13 70.63,52.13 72.36,53.86 77.52,53.86 78.48,54.82 78.48,55.61 81.68,58.81 81.98,58.81 82.95,59.78 v4(82.95,60.5) 82.95,62.51 83.87,63.43 83.87,63.63 84.71,64.48 84.71,64.81 86.73,66.83 87.39,66.83 87.78,67.22 89.77,67.22 89.87,67.12 91.97,67.12 92.63,67.78 94.67,67.78 94.89,67.55 100.21,67.55 100.91,66.85 101.11,66.85 101.41,66.55 102.21,66.55 v2(102.83,65.94)
HP_JACK_DET_L: length 4.1
  TOP w0.109: U3.2 21.54,41.98 22.4,42.84 R188.2 22.4,43.27 22.62,43.49 22.85,43.49 v4(23.18,43.83) 22.88,44.13 R93.1
HP_LEFT: length 3.1
  TOP w0.203: U3.16 16.83,38.62 16.53,38.92 v2(16.34,38.92)
  TOP w0.508: R92.1 15.83,38.92 v2(16.34,38.92)
  BOTTOM w0.203: R184.1 16.75,39.33 v2(16.34,38.92)
HP_MIC_BIAS1: length 1.7
  TOP w0.203: R89.1 23.62,40.22 U3.39
HP_MIC_BIAS2: length 1.5
  TOP w0.203: U3.38 23.29,39.82 23.31,39.84 23.95,39.84 R95.1
HP_MIC_N: length 2.1
  TOP w0.109: C84.1 20.06,42.71 20.01,42.66 v4(20.01,42.63) 20.01,42.11 19.94,42.04 U3.6
HP_MIC_P: length 2.4
  TOP w0.203: C85.1 21.1,42.99 20.33,42.22 U3.5
HP_RIGHT:
  vias: v2(15.23,36.28)
HP_RING1: length 11.6
  TOP w0.508: v2(15.21,34.84) 15.21,34.99 16.02,35.79 R94.2
  BOTTOM w0.508: v2(15.21,34.84) 13.83,34.84 13.68,34.99 12.98,34.99 D12.1 12.32,35.11 7.11,35.11 6.01,36.22 J16.2
HP_RING2: length 27.9
  TOP w0.203: v2(25.09,40.83) 25.04,40.78 R89.2
  TOP w0.508: C84.2 20.06,44.92 19.45,45.53
  IN1 w0.508: v2(25.09,40.83) 23.77,42.15 23.77,44.26 22.75,45.27 20.21,45.27 19.58,45.91 v2(19.58,46.54) 19.32,46.8 14.12,46.8 13.96,46.95 5.63,46.95 4.73,46.05 J16.3
HP_RING2_SENSE: length 8.3
  TOP w0.178: U3.14 16.99,39.42 16.07,40.35
  TOP w0.508: v2(16.07,41.13) 16.07,40.35
  IN1 w0.508: v2(17.93,45.91) 17.8,45.91 17.04,45.15 17.04,42.1 v2(16.07,41.13)
HP_SLEEVE: length 39.1
  TOP w0.203: v2(25.09,40.07) R95.2
  TOP w0.508: C85.2 21.47,44.64 v2(21.86,44.64)
  IN4 w0.508: v2(25.09,40.07) 24.91,40.07 24.15,40.83 24.15,42.35 v2(21.86,44.64) 21.23,44 17.54,44 16.91,44.64 16.91,44.89 v2(15.89,45.91) 15.89,42.1 15.39,41.59 15.39,40.95 15.98,40.36 15.98,39.64 15.62,39.28 15.62,38.06 15.97,37.7 15.97,36.09 15.57,35.69 14.77,35.69 14.09,35.01 4.99,35.01 3.5,36.5 J16.4
HP_SLEEVE_SENSE: length 5.3
  TOP w0.178: 15.99,39.53 16.38,39.53 16.88,39.02 U3.15
  TOP w0.508: v2(15.32,39.93) 15.72,39.53 15.99,39.53
  BOTTOM w0.508: v2(15.32,39.93) 15.32,41.66 16.02,42.35
HP_TERM_MAKETERM: length 28.2
  TOP w0.109: v2(23.53,45.44) 23.5,45.41 R93.2 22.88,45.8 22.46,46.22 D13.1
  IN4 w0.089: J16.6 8.76,36.34 9.69,35.42 13.66,35.42 14.93,36.69 14.93,37.45 15,37.53 15,39.18 14.62,39.56 14.62,43.22 15,43.6 15,45.27 15.39,45.65 15.39,46.04 15.77,46.42 19.07,46.42 19.83,45.65 23.32,45.65 v2(23.53,45.44)
HP_TIP: length 14.4
  TOP w0.508: R92.2 15.33,37.65 v4(15.33,37.3)
  IN1 w0.508: J16.1 13.34,46.05 13.48,45.91 v2(14.88,45.91) 15,45.91 16.25,44.66 16.25,42.45 15.31,41.51 15.31,40.78 16.02,40.07 16.02,39.56 15.64,39.18 15.64,37.6 v4(15.33,37.3)
I2S_HP_AUDIO: length 96.5
  TOP w0.109: v2(24.28,37.78) 23.83,38.22 U3.34
  IN1 w0.097: v2(64.66,49.46) 62.38,49.46 61.57,48.66 61.57,46.63 59.92,44.98 47.81,44.98 44.62,48.17 37.51,48.17 36.17,46.83 31.87,46.83 29.3,44.26 29.3,39.89 28.51,39.1 26.86,39.1 25.55,37.78 v2(24.28,37.78)
  BOTTOM w0.109: R332.1 99.95,60.72 97.81,60.72 97.23,60.14 97.02,60.14 96.68,59.8 96.68,59.79 96.62,59.73 96.62,59.3 96.08,58.76 95.35,58.76 94.04,57.44 93.13,57.44 91.53,55.84 89.54,55.84 89.31,56.07 88.16,56.07 87.31,56.92 87.02,56.92 86.31,57.62 83.2,57.62 78.27,52.69 73.1,52.69 71.14,50.73 71.14,50.1 70.12,49.08 65.04,49.08 v2(64.66,49.46)
I2S_HP_BCLK: length 98.3
  TOP w0.109: U3.31 23.51,37.02 23.64,36.9 v2(23.64,36.89)
  IN1 w0.097: v2(23.64,36.89) 23.64,35.62 23.81,35.46 24.28,35.46 24.38,35.36 24.38,34.7 24.48,34.61 24.76,34.61 24.86,34.7 24.86,35.36 24.95,35.46 25.24,35.46 25.33,35.36 25.33,34.7 25.43,34.61 25.72,34.61 25.81,34.7 25.81,35.36 25.91,35.46 26.19,35.46 26.29,35.36 26.29,34.7 26.39,34.61 26.67,34.61 26.77,34.7 26.77,35.36 26.86,35.46 27.52,35.46 30.63,38.56 30.63,43.88 32.35,45.61 43.58,45.61 45.43,43.76 60.42,43.76 63.59,46.92 66.19,46.92 67.1,47.84 68.95,47.84 69.23,47.56 v2(70,47.56)
  BOTTOM w0.109: v2(70,47.56) 71.27,48.83 71.27,48.96 71.9,49.59 74.1,49.59 v4(75.8,51.28) 76.35,51.84 78.45,51.84 83.44,56.83 86.04,56.83 86.72,56.15 87.05,56.15 87.86,55.34 88.96,55.34 89.21,55.1 92.01,55.1 93.12,56.21 96.35,56.21 97.88,57.74 98.62,57.74 R305.1 98.87,57.89 99.17,58.19 R331.1
I2S_HP_LRCK: length 96
  TOP w0.109: U3.32 23.36,37.42 23.46,37.32 23.84,37.32 v2(24.28,36.89)
  IN1 w0.097: v2(24.28,36.89) 24.28,36.03 24.36,35.94 24.66,35.94 24.74,36.03 24.74,36.79 24.85,36.89 25.02,36.89 25.13,36.79 25.13,36.04 25.23,35.94 25.42,35.94 25.51,36.03 25.51,36.8 25.6,36.89 25.79,36.89 25.89,36.79 25.89,36.04 25.99,35.94 26.18,35.94 26.27,36.03 26.27,37.48 27.17,38.38 29.06,38.38 30.14,39.47 30.14,44.08 32.15,46.08 43.8,46.08 45.63,44.25 60.24,44.25 63.39,47.41 65.3,47.41 66.21,48.32 69.49,48.32 69.77,48.04 70.66,48.04 v2(71.27,47.43)
  BOTTOM w0.109: v2(71.27,47.43) 71.27,47.69 v4(71.58,48) 72.66,49.08 74.31,49.08 76.58,51.35 78.65,51.35 82.96,55.66 86.85,55.66 87.66,54.85 88.74,54.85 88.99,54.6 95.46,54.6 97.52,56.67 98.34,56.67 98.49,56.82 R334.1
I2S_HP_MIC: length 100.6
  TOP w0.109: U3.33 23.6,37.82 v2(23.64,37.78)
  IN1 w0.097: v2(23.64,37.78) 24.02,37.4 25.67,37.4 27,38.73 28.91,38.73 29.71,39.53 29.71,44.16 32.01,46.46 36.34,46.46 37.57,47.69 44.47,47.69 47.53,44.63 60.09,44.63 63.22,47.76 65.16,47.76 66.07,48.67 69.64,48.67 69.91,48.39 70.94,48.39 71.65,47.69 71.65,47.18 v2(71.27,46.8)
  BOTTOM w0.109: v2(71.27,46.8) 72.74,46.8 73.5,47.56 75.89,47.56 v4(78.09,49.76) 83.27,54.94 86.55,54.94 87.95,53.53 89.05,53.53 89.38,53.86 96.03,53.86 97.66,55.49 99.94,55.49 100.7,56.25 100.7,56.81 101.57,57.67 102.96,57.67 103.14,57.86 103.14,58.2 103.37,58.43 104.41,58.43 104.57,58.59 R333.1
I2S_MCLK: length 100.5
  TOP w0.109: R385.1 95.7,67.7 95.42,67.98 94.46,67.98 93.74,68.69 93.74,68.79 v2(93.57,68.97) ; U3.29 21.54,35.72 21.89,35.37 v2(21.89,35.12)
  IN1 w0.097: v2(21.89,35.12) 22.37,35.6 22.37,37.4 23.26,38.29 25.37,38.29 26.67,39.59 28.12,39.59 28.82,40.3 28.82,44.46 31.69,47.33 35.97,47.33 37.3,48.65 44.9,48.65 48.1,45.45 59.7,45.45 61.08,46.83 61.08,48.86 62.19,49.97 v2(62.5,49.97)
  BOTTOM w0.109: v2(62.5,49.97) 62.5,50.61 64.66,52.77 70.38,52.77 71.97,54.36 77.22,54.36 77.96,55.09 77.96,55.98 81.29,59.31 81.73,59.31 82.44,60.02 82.44,62.7 83.36,63.62 83.36,63.82 84.35,64.81 84.35,65.04 84.85,65.54 84.85,65.69 86.21,67.04 87.3,67.04 87.71,67.45 89.13,67.45 89.67,67.99 89.99,67.99 90.36,68.36 91.79,68.36 92.4,68.97 v2(93.57,68.97)
I2S_SPK_AUDIO: length 127.8
  TOP w0.109: v2(24.72,9.8) 24.53,9.99 U4.13 ; v2(20.38,19.25) 20.35,19.28 U2.13
  IN1 w0.097: v2(20.38,19.25) 19.86,18.73 18.43,18.73 17.93,19.24 17.93,24.57 18.79,25.44 19.57,25.44 32.09,37.96 45.78,37.96 50.1,42.27 61.01,42.27 62.07,43.33 70.59,43.33 71.55,44.29 71.55,45.69 72.05,46.19 72.05,47.92 71.18,48.78 v2(70.57,48.78)
  IN4 w0.089: v2(20.38,19.25) 20.38,19.07 21.74,17.71 21.74,11.62 23.01,10.35 24.17,10.35 v2(24.72,9.8)
  BOTTOM w0.109: v2(70.57,48.78) 71.9,50.11 71.9,50.73 v4(73.04,51.88) 73.5,52.33 74.02,52.33 74.12,52.22 74.12,51.48 74.23,51.37 74.57,51.37 74.76,51.56 74.76,52.14 74.95,52.33 78.42,52.33 83.3,57.21 86.19,57.21 86.86,56.54 87.18,56.54 88.01,55.71 89.14,55.71 89.37,55.47 91.79,55.47 93.38,57.06 96.68,57.06 98.06,58.44 98.06,58.94 98.34,59.21 98.73,59.21 99.03,58.92 100.3,58.92 100.5,59.12 R336.1
I2S_SPK_BCLK: length 128.7
  TOP w0.109: v2(16.53,20.89) 16.53,21.02 17.01,21.5 U2.7 ; v2(20.57,11.24) 20.95,11.62 20.95,11.77 21.26,12.08 U4.7
  IN1 w0.097: v2(64.43,46.06) 63.41,46.06 60.61,43.26 49.74,43.26 45.4,38.92 31.68,38.92 26.27,33.51 26.13,33.51 25.52,34.12 25.39,34.12 25.19,33.92 25.19,33.78 25.79,33.17 25.79,33.04 25.59,32.84 25.46,32.84 24.85,33.44 24.71,33.44 24.51,33.24 24.51,33.1 25.12,32.5 25.12,32.36 20.63,27.87 19.22,27.87 17.75,26.4 17.75,25.79 16.91,24.95 16.91,22.44 16.81,22.34 16.3,22.34 16.2,22.25 16.2,21.96 16.3,21.87 16.81,21.87 16.91,21.77 16.91,21.27 v2(16.53,20.89)
  IN4 w0.089: v2(20.57,11.24) 20.57,12.79 20.21,13.14 20.21,14.41 19.07,15.56 19.07,18.1 16.53,20.64 v2(16.53,20.89)
  BOTTOM w0.109: v2(64.43,46.06) 64.03,46.47 64.03,49.85 v4(64.85,50.67) 65.55,51.37 71.14,51.37 72.83,53.07 78.02,53.07 83.03,58.08 86.41,58.08 87.2,57.29 87.8,57.29 87.83,57.26 90.43,57.26 90.56,57.39 91.43,57.39 92.97,58.94 93.49,58.94 94.54,59.99 94.54,62.53 94.84,62.83 95.88,62.83 96.23,63.18 96.75,63.18 97.23,63.67 99.22,63.67 99.49,63.95 100.28,63.95 R335.1
I2S_SPK_LRCK: length 130.4
  TOP w0.109: U4.11 v2(23.53,9.86) ; v2(19.25,19.24) 19.35,19.34 U2.11
  IN1 w0.097: v2(72.92,48.58) 72.53,48.19 72.53,45.99 72.03,45.49 72.03,44.09 70.79,42.85 62.28,42.85 61.2,41.77 50.27,41.77 45.23,36.72 31.54,36.72 24.91,30.09 24.91,29.14 25.01,29.04 25.37,29.04 25.51,28.9 25.51,28.66 25.42,28.57 25.01,28.57 24.91,28.47 24.91,28.19 25.01,28.09 25.53,28.09 25.64,27.98 25.64,27.73 25.51,27.61 23.44,27.61 20.78,24.95 18.99,24.95 18.41,24.37 18.41,20.08 v2(19.25,19.24)
  IN4 w0.089: v2(23.53,9.86) 22.61,9.86 21.23,11.24 21.23,17.49 19.68,19.04 19.45,19.04 v2(19.25,19.24)
  BOTTOM w0.109: R337.1 103.42,58.81 103.05,58.45 102.57,58.45 102.08,57.95 101.26,57.95 100.21,56.89 100.21,56.51 99.56,55.87 97.4,55.87 95.76,54.23 88.84,54.23 88.63,54.45 87.55,54.45 86.7,55.3 83.12,55.3 78.72,50.91 76.8,50.91 76.07,50.18 76.07,50.03 76.88,49.22 76.88,49.06 76.69,48.87 76.53,48.87 75.72,49.68 75.57,49.68 75.38,49.49 75.38,49.33 76.19,48.52 76.19,48.37 75.99,48.18 75.84,48.18 75.03,48.99 74.88,48.99 74.47,48.58 v2(72.92,48.58)
IBAT_N: length 35.1
  TOP w0.203: U9.8 58.61,17.07 v2(58.51,16.98)
  IN4 w0.305: v2(58.51,16.98) 59.23,17.69 63.82,17.69 67.02,14.49 79.32,14.49 79.77,14.95 82.87,14.95 83.55,14.27 v2(83.55,13.55)
  BOTTOM w0.305: v2(58.51,16.98) 59.06,16.98 C1017.1 59.27,16.95 60.12,16.95 C212.2 ; v2(83.55,13.55) 83.55,14.5 83.1,14.95 83.1,16.12 83.29,16.31 83.29,17.24 R229.2
IBAT_P: length 34.3
  TOP w0.203: U9.9 58.84,16.67 58.51,16.34 v2(58.51,16.32)
  IN4 w0.305: v2(82.95,13.55) 82.95,14.05 82.68,14.31 79.96,14.31 79.58,13.93 66.74,13.93 63.54,17.13 59.48,17.13 58.67,16.32 v2(58.51,16.32)
  BOTTOM w0.305: v2(58.51,16.32) 58.57,16.37 58.85,16.37 C1015.1 59.39,16.32 60,16.32 C212.1 ; v2(82.95,13.55) 82.95,14.31 82.52,14.74 82.52,16.37 82.7,16.55 82.7,17.33 R228.1
IMVP9_IMON: length 2
  TOP w0.109: U10.11 182.49,53.02 v2(182.84,52.67)
  BOTTOM w0.114: v2(182.84,52.67) 182.93,52.67 R275.2
IMVP9_ISEN1N: length 30.3
  TOP w0.203: R27223.2 159.91,67.26 159.91,67.75 v2(159.96,67.8) ; v2(179.21,58.91) 179.39,58.74 C404.1 179.87,58.3 179.89,58.33 180.2,58.33 R425.2 180.4,58.82 180.14,59.08 180.14,59.53 R427.2 180.01,59.79 180.01,60.36 179.92,60.45 C403.2
  BOTTOM w0.203: v2(159.96,67.8) 159.95,67.81 159.95,68.1 160.24,68.39 v4(160.61,68.39) 160.86,68.39 162.78,66.47 172.69,66.47 174.32,64.84 175.61,64.84 176.75,63.7 176.75,61.83 179.21,59.38 v2(179.21,58.91)
IMVP9_ISEN1N_R: length 3.4
  TOP w0.109: v4(181.22,58.61) 180.91,58.3 180.87,58.3 180.65,58.08 180.65,58.08 180.4,57.84 R425.1
  TOP w0.203: U10.19 180.27,57.62 R425.1
IMVP9_ISEN1P: length 21.6
  TOP w0.203: v2(175.66,61.78) 175.91,61.53 176.11,61.53 R430.2 ; R27222.2 161,67.34 v2(160.57,67.77)
  BOTTOM w0.203: v2(160.57,67.77) 160.59,67.79 160.94,67.79 162.62,66.11 172.59,66.11 174.18,64.51 175.47,64.51 176.42,63.56 176.42,62.55 v4(176.11,62.23) v2(175.66,61.78)
IMVP9_ISEN1P_R: length 7.1
  TOP w0.203: R429.1 178.02,60.46 v4(177.69,60.13) 178.34,60.13 R427.1 178.74,58.7 178.89,58.55 178.89,57.79 179.16,57.52 C404.2 179.87,57.04 U10.20
IMVP9_ISEN2: length 4.4
  TOP w0.191: R365.1 181.7,57.03 181.31,56.64 181.31,56.49 181.07,56.24 U10.17
  TOP w0.203: U10.18 180.67,56.58 v4(180.77,56.68) 181.11,57.02 181.11,57.08 181.45,57.42 R365.1
IMVP9_LGATE1: length 12.8
  TOP w0.203: 176.11,53.24 176.37,53.24 176.95,53.82 U10.28
  TOP w0.635: 176.11,53.24 175.6,52.73 v4(174.61,52.73) 173.96,52.08
  IN2 w0.762: v3(173.83,50.95) 173.16,51.62 169.18,51.62 168.34,50.78 v2(168.34,48.51)
IMVP9_PHASE1: length 14.8
  TOP w0.203: L27202.1 162.44,60.62 161.9,61.17 161.9,64.75 160.77,65.88 160.77,66.19 R27222.1 ; U10.27 176.71,54.22 176.62,54.13 176.36,54.13
  TOP w0.381: 163.7,55.17 162.55,55.17 R27221.1
  TOP w0.635: 176.36,54.13 175.73,54.13 175.39,53.79 C234.1
  vias: v4(167.41,56.27)
IMVP9_SET1: length 3.2
  TOP w0.109: R135.1 181.7,50 v2(181.61,50.09) 181.61,50.32 181.07,50.86 U10.8
  BOTTOM w0.114: v2(181.61,50.09) 181.7,50 R135.1
IMVP9_SET2: length 3.3
  TOP w0.109: U10.7 180.67,50.55 v2(180.87,50.35) 180.87,49.94 180.94,49.87 R143.2
  BOTTOM w0.114: v2(180.87,50.35) 180.87,49.76 180.94,49.69 R143.2
IMVP9_SET3: length 3.1
  TOP w0.109: U10.6 180.27,50.94 180.08,50.76 180.08,50.53 180.1,50.51 v2(180.1,50.1) 180.1,49.86 180.18,49.79 R235.1
  BOTTOM w0.114: v2(180.1,50.1) 180.1,49.86 180.18,49.79 R235.1
IMVP9_SVID_ALERT_ODL: length 87.3
  TOP w0.109: v2(124.86,82.15) 124.86,81.66 R3F13.2 ; v2(178.39,50.49) 178.39,50.54 179.07,51.22 U10.3
  BOTTOM w0.109: v2(178.39,50.49) 178.39,50.93 178.94,51.48 180.78,51.48 181.99,51.29 184.4,51.29 184.8,51.69 185.42,53.97 185.42,58.47 180.31,63.57 174.78,67.5 174.78,67.51 174.53,67.68 167.4,69.13 165.67,70.86 163.24,70.86 162.28,71.82 161.69,74.2 161.22,74.67 158.67,76.26 156.46,78.47 153.85,78.47 150.75,81.57 137.39,81.57 135.16,83.81 131.16,83.81 125.34,82.54 125.21,82.47 v2(124.86,82.15)
IMVP9_SVID_CLK: length 88.8
  TOP w0.109: R2F1.2 179.29,49.92 179.57,50.2 v2(179.57,50.48) 179.57,50.61 179.87,50.9 U10.5 ; R2F3.2 125.95,82.08 v2(125.88,82.15)
  BOTTOM w0.109: v2(179.57,50.48) 179.5,50.2 179.32,49.94 179.09,49.85 178.33,49.85 177.87,50.3 177.87,51.1 178.74,51.97 180.99,51.97 182.35,51.78 184.19,51.78 184.36,51.94 184.93,54.04 184.93,58.26 180,63.2 174.33,67.22 167.16,68.68 165.47,70.37 162.93,70.37 161.72,71.59 161.19,73.96 161.07,74.09 158.46,75.75 156.25,77.96 153.67,77.96 150.55,81.08 137.19,81.08 134.95,83.32 131.21,83.32 v2(125.88,82.15)
IMVP9_SVID_DATA: length 90
  TOP w0.109: R318.2 178.36,49.69 178.99,50.32 v2(178.99,50.48) 179.47,51.22 U10.4 ; v2(124.17,82.15) R2F14.2
  BOTTOM w0.109: v2(124.17,82.15) 124.38,82.39 124.63,82.61 124.93,82.88 125.17,83 131.1,84.3 135.36,84.3 137.58,82.08 150.94,82.08 154.04,78.98 156.66,78.98 158.87,76.77 161.4,75.26 162.18,74.47 162.8,72.02 163.47,71.35 165.88,71.35 167.65,69.58 174.73,68.14 174.85,68.05 174.86,68.05 180.63,63.95 185.91,58.67 185.91,53.91 185.24,51.43 184.6,50.8 181.95,50.8 180.74,50.99 179.47,50.99 179.35,50.95 179.13,50.76 v2(178.99,50.48)
IMVP9_TSEN: length 10.2
  TOP w0.109: R274.1 174.05,61.78 v2(174.26,61.78)
  TOP w0.203: v2(179.34,56.92) 179.34,56.8 179.47,56.67 U10.21
  BOTTOM w0.114: R271.1 178.97,57.59 178.45,58.11 178.45,59.24 178.07,59.62 176.68,59.62 175.79,60.51 175.53,60.51 v4(174.93,61.11) v2(174.26,61.78)
  BOTTOM w0.203: v2(179.34,56.92) 179.24,57.02 R271.1
IMVP9_TSEN_SET: length 9.6
  TOP w0.109: v2(174.26,62.42) 174.19,62.42 R274.2
  BOTTOM w0.114: R264.1 179.95,58.54 179.97,58.52 R237.2 R271.2 178.96,58.04 178.69,58.3 178.69,59.34 178.17,59.87 177.68,59.87 v4(177.39,60.16) 176.53,60.16 v2(174.26,62.42)
IMVP9_UGATE1: length 3.7
  IN2 w1.016: 175.02,55.31 172.87,57.47 172.87,58.1
  vias: v2(172.94,59.49) v2(172.94,58.8) v2(175.97,54.91) v2(176.7,54.94)
IMVP9_VREF06: length 50.2
  TOP w0.109: v2(182.84,53.34) 182.76,53.42 U10.12 ; v2(163.82,67.35) 163.61,67.13 R268.2
  BOTTOM w0.114: 179.22,53.02 180.87,53.02 181.13,52.75 181.51,52.75 182.14,53.39 R362.1 182.2,53.34 v2(182.84,53.34) 183.19,52.99 R269.1 183.38,53.91 183.86,54.39 183.86,58.12 181.61,60.37 180.49,60.37 175.72,65.13 174.44,65.13 172.81,66.76 163.96,66.76 163.82,66.9 v2(163.82,67.35) ; 179.22,53.02 179.22,55.13 179.97,55.89 R237.1 ; 179.22,53.02 178.07,53.02 v4(177.38,52.33) 177.38,50.1 178.52,48.95 R233.1 R141.1 R133.1
IMVP9_VRHOT_L: length 2.7
  TOP w0.109: U10.2 178.67,51.2 178.44,50.98 177.69,50.98 177.49,50.78 v4(177.49,50.66) 177.49,50.02 R27113.2
IMVP9_VRRDY_OD: length 142.8
  TOP w0.117: v2(89.52,43.02) 89.52,43.35 89.38,43.49 R338.1
  TOP w0.178: v2(177.57,56.95) 177.57,56.5 177.9,56.17 178.01,56.17 178.27,55.92 U10.24
  TOP w0.203: R27106.2 176.31,56.95 v2(177.57,56.95)
  IN1 w0.097: v2(177.57,56.95) 178.2,56.32 180.38,56.32 181.88,54.82 181.88,51.88 182.14,51.62 182.14,42.56 183.41,41.29 183.41,36.51 182.77,35.88 181.63,35.88 181.15,35.39 v2(181.15,35.24)
  IN2 w0.097: v2(89.52,43.02) 90.06,42.47 90.06,41.62 89.35,40.91 89.35,31.86 94.57,26.65 99.72,26.65 100.56,25.81 114.2,25.81 115.05,24.96 131.13,24.96 131.35,24.73 135.56,24.73 137.92,27.09 139.87,27.09 143.66,30.88 150.37,30.88 150.84,30.41 153.84,30.41 154.35,29.91 156.61,29.91 157.82,31.12 162.66,31.12 163.75,32.21 169,32.21 169.59,32.81 178.71,32.81 v2(181.15,35.24)
INTRUDER_L: length 24.1
  TOP w0.089: 104.9,43.42 105.49,44.02 105.49,44.37 109.25,48.12 109.25,48.66 110,49.41 110,51.13 U1JSL.BP51
  TOP w0.117: R3C18.2 R2C20.1 92.69,42.47 v4(92.88,42.66) 93.32,42.66 93.56,42.9 104.38,42.9 104.9,43.42
KB_BL_IN:
  vias: v4(75.68,12.63)
KB_BL_ISET: length 2.2
  TOP w0.109: U5.A1 78.29,11.66 78.75,12.12 R91353.1
KB_BL_LED1: length 9.1
  TOP w0.109: v2(78.63,10.67) 78.63,10.69 78.46,10.86 U5.A3
  BOTTOM w0.114: CN2.1 77.1,17.04 77.22,16.91 77.78,16.91 78.08,16.61 78.08,13.96 79.04,13 79.04,11.07 v2(78.63,10.67)
KB_BL_LED2: length 8.9
  TOP w0.109: U5.A2 v2(78.62,11.26)
  BOTTOM w0.114: v2(78.62,11.26) 78.64,11.26 78.78,11.4 78.78,12.91 77.74,13.96 77.74,16.48 77.59,16.64 76.51,16.64 76.1,17.05 CN2.2
KB_BL_PWM: length 174.1
  TOP w0.079: v1(158.31,24.27) 158.29,24.24 158.29,24.22 157.96,23.89 157.5,23.89 157.37,24.02 156.16,24.02 U17.K6
  TOP w0.109: U5.B1 77.68,11.72 v2(78.28,12.32) 78.08,12.51 78.08,13.9 78.46,14.28 R91351.1
  IN1 w0.097: v2(95.45,16.41) 91.98,12.94 88.33,12.94 87.23,11.83 85.43,11.83 84.56,12.7 78.66,12.7 v2(78.28,12.32)
  IN2 w0.097: v1(158.31,24.27) 158.79,23.79 158.79,22.4 158.58,22.19 158.58,21.72 157.66,20.8 153.83,20.8 153.18,20.15 152.36,20.15 152.07,20.45 151.26,20.45 151.25,20.46 148.25,20.46 143.12,15.33 116.16,15.33 112.99,18.5 110.9,18.5 110.71,18.7 105.05,18.7 104.79,18.44 103.08,18.44 102,17.36 96.39,17.36 v2(95.45,16.41)
  IN4 w0.089: v1(158.31,24.27) 159.71,22.87 160.34,22.87 161.85,21.36 163.11,21.36 163.57,20.9 163.57,18.06 163.8,17.82 164.86,17.82 165.13,18.09 165.13,18.87 166.34,20.08 166.59,20.08 168.01,21.5 172.11,21.5 173.93,19.68 180.12,19.68 182.02,21.58 182.02,24.83 183.61,26.42 183.61,27.49 186.37,30.24 186.37,42.2 185.5,43.06 185.5,47.62 185.9,48.02 186.78,48.02 v2(187.58,48.81)
  BOTTOM w0.114: v2(187.58,48.81) 187.73,48.65 193.41,48.65 195.42,50.66 195.42,54.04 194.31,55.15 J12.11
KB_ID: length 1.6
  TOP w0.079: U17.E4 v1(152.26,22.72)
  BOTTOM w0.114: R937.2 152.01,22.13 152.26,22.38 v1(152.26,22.72)
KBD_PWR_BTN_GND: length 11.4
  TOP w0.109: R191.1 122.82,20.45 122.87,20.4 R98.2 124.21,20.4 124.68,20.87 v2(124.68,20.97)
  BOTTOM w0.114: J25.27 123.07,17.87 123.79,18.59 124.38,18.59 124.78,19 124.78,19.38 124.68,19.48 v2(124.68,20.97) 124.68,23.45 124.78,23.55 J17.27
KBD_PWR_BTN_ODL: length 11.6
  TOP w0.109: R193.1 125.51,21.89 R192.2 125.84,20.92 v2(125.81,20.89) 126.08,20.62 D16.1
  BOTTOM w0.114: J17.25 126.38,22.03 125.9,21.55 125.9,20.98 v2(125.81,20.89) 126.26,20.44 126.26,18.79 125.74,18.27 125.05,18.27 124.67,17.9 J25.25
KSI_00: length 32.7
  TOP w0.079: U17.A2 149.8,20.9 149.3,20.9 149.29,20.88 149.26,20.88 149.08,20.71
  TOP w0.109: D2.3 136.2,19.57 135.33,18.7 v2(135.2,18.7) ; 149.08,20.71 148.34,19.97 148.34,19.35 147.49,18.5 147.49,18.22 147.24,17.97 R27300.2 147.16,17.66 146.96,17.46 146.65,17.46 144.75,19.37 144.75,20.74 145,20.99 145,21.37 v2(145.36,21.73)
  IN2 w0.097: v2(135.2,18.7) 135.87,18.7 138.94,21.76 145.32,21.76 v2(145.36,21.73)
  BOTTOM w0.114: J17.13 135.98,23.34 136.24,23.08 136.24,19.61 135.33,18.7 v2(135.2,18.7) 135.18,18.7 134.27,17.79 J25.13
KSI_01: length 40.1
  TOP w0.079: 148.81,21.44 149.14,21.78 v1(149.14,22.03) 149.5,21.68 149.92,21.68 U17.A3
  TOP w0.109: R27299.2 147.49,19.39 147.85,19.75 147.85,20.48 148.81,21.44 ; D16.4 127.25,20.18 127.45,19.98 127.45,19.4 127.15,19.1 127.15,18.99 v2(126.86,18.7)
  IN4 w0.089: v2(126.86,18.7) 127.65,17.9 133,17.9 133.2,17.7 144.81,17.7 v1(149.14,22.03)
  BOTTOM w0.114: J17.24 127.18,23.87 127.05,23.74 127.05,18.89 v2(126.86,18.7) 126.51,18.7 125.47,17.66 J25.24
KSI_02: length 61
  TOP w0.079: R3001.2 162.24,20.81 v1(162.25,20.8)
  TOP w0.109: v2(132.1,18.7) 132.39,18.98 D1.3 ; v1(163.59,26.18) 163.34,25.92 R3006.1
  IN2 w0.097: v2(145.43,21.14) 145.26,21.14 144.83,21.57 139.04,21.57 135.57,18.1 132.7,18.1 v2(132.1,18.7) ; v1(162.25,20.8) 162.25,21.04 163.07,21.87 163.07,22.15 162.45,22.77 162.45,24.5 163.42,25.46 163.42,25.89 163.59,26.07 163.59,26.17 163.59,26.17 v1(163.59,26.18)
  BOTTOM w0.114: J25.17 131.07,17.86 131.41,18.2 131.61,18.2 v2(132.1,18.7) 132.29,18.88 132.29,22.48 132.95,23.14 132.95,23.84 132.78,24 J17.17 ; v2(145.43,21.14) 145.2,21.14 144.86,20.8 144.86,14.46 145.38,13.94 152.31,13.94 154.09,15.72 154.09,17.11 154.69,17.7 158.75,17.7 161.85,20.8 v1(162.25,20.8)
KSI_03: length 64.1
  TOP w0.109: R3002.2 159.73,21.09 159.23,20.59 159.23,17.11 159.86,16.47 159.86,15.51 159.58,15.23 155.57,15.23 154.98,14.64 153.99,14.64 153.43,15.2 148.56,15.2 144.42,19.34 144.42,21.02 v2(144.57,21.17) ; v2(132.7,18.7) 132.9,18.89 132.9,20.08 132.71,20.27 D1.4 132.39,20.5 132.33,20.55 132.33,21.05 131.81,21.57 R192.1 ; v2(146.5,19.95) 146.73,20.18 R3005.1
  IN4 w0.089: v2(132.7,18.7) 133.49,17.9 144.19,17.9 146.24,19.95 v2(146.5,19.95)
  BOTTOM w0.114: J25.16 131.87,17.87 v2(132.7,18.7) 133.88,19.87 133.88,23.58 133.58,23.88 J17.16 ; v2(146.5,19.95) 146.5,19.96 146.58,20.03 146.58,21.58 145.86,22.29 145.15,22.29 144.57,21.7 v2(144.57,21.17)
KSI_04: length 34.2
  TOP w0.079: U17.B4 150.28,22.75 148.78,22.75 148.48,23.05 147.87,23.05 147.79,23.13
  TOP w0.109: D17.4 129.3,20.22 129.73,20.65 v2(129.73,20.97) ; 147.79,23.13 147.14,23.78 145.94,23.78 R27296.2 145.38,23.4 144.67,22.69 143.26,22.69 v1(142.8,23.15)
  IN1 w0.097: v2(129.73,20.97) 130.82,19.87 133.79,19.87 134.28,20.37 134.28,21.37 134.6,21.69 141.14,21.69 142.6,23.15 v1(142.8,23.15)
  BOTTOM w0.114: J17.20 130.38,24 130.05,23.68 130.05,21.3 v2(129.73,20.97) 129.73,18.99 128.67,17.93 J25.20
KSI_05: length 39.1
  TOP w0.079: U17.C3 v1(150.96,22.07) 150.96,21.68 150.68,21.4 149.9,21.4 149.6,21.1 148.92,21.1 148.81,20.98
  TOP w0.109: R27295.2 147.29,18.68 148.1,19.49 148.1,20.27 148.81,20.98 ; D1.1 131.37,20.27 131.04,19.94 131.04,18.82 v2(130.91,18.7)
  IN1 w0.097: v2(130.91,18.7) 130.91,18.6 131.21,18.3 145.76,18.3 148.99,21.53 149.76,21.53 150.29,22.07 v1(150.96,22.07)
  BOTTOM w0.114: J25.19 129.47,17.94 130.22,18.7 v2(130.91,18.7) 131.04,18.82 131.04,23.84 131.18,23.97 J17.19
KSI_06: length 38.4
  TOP w0.079: U17.D5 v1(151.61,23.37)
  TOP w0.109: D17.2 128.25,18.79 v2(128.07,18.62)
  IN1 w0.079: 151.02,21.52 151.28,21.79 151.28,23.04 v1(151.61,23.37)
  IN1 w0.097: v2(128.07,18.62) 128.59,18.1 145.84,18.1 149.07,21.33 149.94,21.33 150.13,21.52 151.02,21.52
  BOTTOM w0.079: v1(151.61,23.37) 151.29,23.69 151.29,24.4 R27294.2
  BOTTOM w0.114: J17.22 128.78,23.8 128.86,23.72 128.86,19.41 v2(128.07,18.62) 127.86,18.62 127.07,17.82 J25.22
KSI_07: length 37.8
  TOP w0.079: 148.21,24.83 149.3,24.83 149.34,24.79 149.62,24.79 149.75,24.65 150.98,24.65 U17.C7
  TOP w0.109: 148.21,24.83 147.56,24.83 147.51,24.78 R27293.2 147.18,25.08 147.05,25.22 143.38,25.22 142.82,24.66 v1(142.82,23.7) ; D17.1 128.25,20.57 v2(127.85,20.97)
  IN1 w0.097: v2(127.85,20.97) 128.34,21.47 130.22,21.47 131.6,20.09 133.69,20.09 134.08,20.49 134.08,21.46 134.53,21.91 141.02,21.91 v1(142.82,23.7)
  BOTTOM w0.114: J17.23 127.98,21.11 v2(127.85,20.97) 127.85,19.03 127.09,18.27 126.63,18.27 126.27,17.91 J25.23
KSO_00: length 31.8
  TOP w0.079: 147.79,23.48 147.86,23.4 149.78,23.4 149.8,23.38 150.3,23.38 U17.B5
  TOP w0.109: v2(131.51,18.7) 131.61,18.79 D1.2 ; v1(143.62,23.15) 144.73,23.15 145.6,24.01 147.26,24.01 147.79,23.48
  IN2 w0.097: v1(143.62,23.15) 142.83,22.36 139.24,22.36 136.17,19.29 132.1,19.29 v2(131.51,18.7)
  BOTTOM w0.114: J17.18 131.98,23.15 131.34,22.5 131.34,18.87 v2(131.51,18.7) 131.09,18.27 130.59,18.27 130.27,17.95 J25.18
KSO_01: length 30.5
  TOP w0.079: U17.B7 v1(150.96,24.02)
  TOP w0.109: v2(134.58,18.7) 135.42,19.53 D2.2
  IN1 w0.097: v1(150.96,24.02) 150.91,24.07 150.77,24.07 150.13,23.43 150.13,23.18 149.62,22.67 147.86,22.67 147.56,22.37 147.56,21.54 145.34,19.33 143.24,19.33 142.69,19.88 137.92,19.88 137.43,19.39 135.27,19.39 v2(134.58,18.7)
  BOTTOM w0.114: J17.14 135.18,23.56 135.34,23.4 135.34,19.45 v2(134.58,18.7) 134.19,18.7 133.47,17.98 J25.14
KSO_02: length 46.5
  TOP w0.079: 163.74,24.54 163.47,24.27 163.12,24.27 162.83,23.98 162.83,23.4 163.39,22.85 163.74,22.85 U13.B8
  TOP w0.109: v1(163.35,27.05) 163.98,26.42 163.98,25.82 163.75,25.59 163.75,24.55 163.74,24.54 ; D2.4 136.45,20.27 136.86,20.67 v2(136.86,20.89)
  IN2 w0.097: v2(136.86,20.89) 136.86,21.08 138.53,22.75 141.04,22.75 142.73,24.44 145.18,24.44 145.77,23.85 147.16,23.85 147.46,23.55 149.04,23.55 150.36,24.86 153.23,24.86 155.39,27.02 156.77,27.02 157.09,27.34 159.51,27.34 160.09,27.93 162.71,27.93 163.34,27.29 163.34,27.06 v1(163.35,27.05)
  BOTTOM w0.114: J25.12 135.07,17.9 136.86,19.69 v2(136.86,20.89) 136.78,20.97 J17.12
KSO_03: length 25
  TOP w0.079: 148.81,26.27 148.83,26.27 148.85,26.29 U17.A10
  TOP w0.109: 148.81,26.27 146.27,26.27 v2(145.82,26.72) ; D3.1 139.34,20.87 v2(139.14,21.07)
  IN4 w0.089: v2(145.82,26.72) 145.82,26.27 144.09,24.54 143.89,24.54 143.2,23.84 143.2,23.05 141.77,21.62 139.59,21.62 139.14,21.17 v2(139.14,21.07)
  BOTTOM w0.114: J25.11 135.87,18.2 138.74,21.07 v2(139.14,21.07) 137.58,22.63 J17.11
KSO_04: length 31
  TOP w0.079: U17.D7 152.26,24.02 v1(152.26,24.01)
  TOP w0.109: v2(134.85,20.89) 135.04,20.89 135.42,20.52 D2.1
  IN1 w0.097: v2(134.85,20.89) 135.46,20.28 142.89,20.28 143.43,19.75 145.15,19.75 146.6,21.19 146.6,22.18 147.75,23.33 148.67,23.33 149.91,24.58 151.7,24.58 152.26,24.02 v1(152.26,24.01)
  BOTTOM w0.114: J17.15 134.38,21.36 v2(134.85,20.89) 134.85,20.16 132.67,17.97 J25.15
KSO_05: length 25.2
  TOP w0.079: 148.81,26.94 U17.A11
  TOP w0.109: v1(147.24,27.21) 147.63,26.82 148.55,26.82 148.68,26.94 148.81,26.94 ; D3.3 v2(140.12,19.29)
  IN4 w0.089: v1(147.24,27.21) 147.46,26.99 147.46,25.63 146.17,24.34 145.67,24.34 145.08,23.75 145.08,23.74 145.08,23.35 144.12,22.39 143.53,22.39 142.9,21.76 142.9,20.67 141.82,19.59 140.42,19.59 v2(140.12,19.29)
  BOTTOM w0.114: J25.8 138.27,17.93 139.04,18.7 139.53,18.7 v2(140.12,19.29) 140.45,19.62 140.45,23.28 139.98,23.75 J17.8
KSO_06: length 24
  TOP w0.109: D3.2 v2(139.34,19.29)
  IN4 w0.089: v1(146.67,27.21) 146.79,27.09 146.79,26.15 144.88,24.24 144.88,23.45 144.04,22.6 143.44,22.6 142.01,21.17 142.01,20.38 141.61,19.98 140.03,19.98 139.63,19.58 139.63,19.58 v2(139.34,19.29)
  BOTTOM w0.114: D1001.2 147.07,26.81 v1(146.67,27.21) ; J25.9 137.47,17.83 138.93,19.29 v2(139.34,19.29) 139.61,19.55 139.61,23.38 139.18,23.8 J17.9
KSO_06_D: length 2.7
  TOP w0.079: v1(150.96,25.32) 150.96,25.32 U17.C8
  BOTTOM w0.114: D1001.1 150.22,26.16 150.1,26.04 R27301.2 150.61,25.67 150.95,25.32 v1(150.96,25.32)
KSO_07: length 36.9
  TOP w0.079: v1(151.61,24.01) 151.6,24.01 U17.C6
  TOP w0.109: D17.3 129.03,18.96 v2(128.66,18.59)
  IN1 w0.097: v2(128.66,18.59) 129.73,19.66 137.36,19.66 137.78,20.08 142.8,20.08 143.22,19.66 143.22,19.65 143.32,19.54 145.26,19.54 146.8,21.09 146.8,22 147.72,22.92 148.53,22.92 149.96,24.35 151.28,24.35 151.61,24.02 v1(151.61,24.01)
  BOTTOM w0.114: J17.21 129.58,23.82 129.75,23.65 129.75,22.78 129.23,22.26 129.23,19.16 v2(128.66,18.59) 127.87,17.8 J25.21
KSO_08: length 21.9
  TOP w0.079: v1(150.96,25.97) U17.C9
  TOP w0.109: v2(143.89,20.58) 143.16,19.84 D4.3
  IN1 w0.097: v2(143.89,20.58) 143.5,20.97 143.5,21.37 144.49,22.36 144.49,24.04 145.77,25.33 147.16,25.33 147.57,25.74 150.74,25.74 v1(150.96,25.97)
  BOTTOM w0.114: J25.2 143.07,19.75 v2(143.89,20.58) 143.47,21 143.47,21.64 144.78,22.95 J17.2
KSO_09: length 45.9
  TOP w0.079: 148.84,27.24 150.08,27.24 150.26,27.06 150.26,26.81 150.46,26.61 150.97,26.61 U17.C10
  TOP w0.109: v1(147.81,27.21) 147.83,27.24 148.84,27.24 ; v2(122.99,19.09) 123.29,19.39 R98.1 ; v2(142.12,19.29) D4.2
  IN2 w0.097: v2(122.99,19.09) 122.99,18.99 124.47,17.51 140.33,17.51 v2(142.12,19.29)
  IN4 w0.089: v2(142.12,19.29) 142.21,19.29 143.1,20.18 143.1,21.68 143.6,22.19 144.21,22.19 145.28,23.25 145.28,23.54 145.88,24.14 146.27,24.14 147.81,25.68 v1(147.81,27.21)
  BOTTOM w0.114: J25.3 142.27,18.72 142.12,18.88 v2(142.12,19.29) 143.1,20.27 143.1,21.77 144.16,22.83 144.16,23.78 143.98,23.96 J17.3
KSO_10: length 24.8
  TOP w0.079: v1(152.26,25.32) 152.26,25.32 U17.E8
  TOP w0.109: D3.4 140.17,20.32 v2(140.92,21.07)
  IN1 w0.097: v2(140.92,21.07) 141.51,20.48 142.99,20.48 143.53,19.95 144.19,19.95 144.98,20.74 144.98,21.91 145.38,22.31 146.44,22.31 147.66,23.53 148.58,23.53 149.83,24.78 151.72,24.78 152.26,25.32 v1(152.26,25.32)
  BOTTOM w0.114: J25.5 140.67,17.08 140.68,17.08 140.68,19.34 140.92,19.59 v2(140.92,21.07) 142.38,22.53 J17.5
KSO_11: length 22
  TOP w0.079: U17.B10 150.37,26.29 150.03,26.63 148.81,26.63 148.81,26.63
  TOP w0.109: v1(146.42,26.72) 146.62,26.52 148.7,26.52 148.81,26.63 ; D4.1 142.12,20.67 v2(141.61,21.17)
  IN4 w0.089: v1(146.42,26.72) 146.4,26.69 146.4,26.02 144.69,24.31 144.69,23.55 143.94,22.8 143.34,22.8 141.71,21.17 v2(141.61,21.17)
  BOTTOM w0.114: J17.4 143.18,23.91 143.21,23.88 143.21,22.76 v2(141.61,21.17) 141.61,20.76 141.47,20.61 J25.4
KSO_12: length 21.8
  TOP w0.079: U17.D8 151.61,25.32 v1(151.61,25.32)
  TOP w0.109: D4.4 143.05,20.32 v2(143.89,21.17)
  IN1 w0.097: v2(143.89,21.17) 144.78,22.06 144.78,24.04 145.87,25.13 147.26,25.13 147.62,25.49 150.06,25.49 150.56,24.98 151.28,24.98 151.61,25.32 v1(151.61,25.32)
  BOTTOM w0.114: J17.1 145.58,23.4 143.79,21.61 143.79,21.27 v2(143.89,21.17) 144.32,20.75 144.32,20.31 143.87,19.86 J25.1
KSO_13: length 41.9
  TOP w0.079: U17.E6 v1(152.91,23.37)
  TOP w0.109: D16.3 126.77,19.7 126.06,18.99 126.06,18.99 125.76,18.7 v2(125.57,18.7)
  IN1 w0.079: 152.59,22.33 152.59,23.04 v1(152.91,23.37)
  IN1 w0.097: v2(125.57,18.7) 125.76,18.7 126.56,17.9 145.92,17.9 149.11,21.09 150.08,21.09 150.26,21.27 151.53,21.27 152.59,22.33
  BOTTOM w0.114: J25.26 123.87,17.99 124.19,18.31 124.56,18.31 124.95,18.7 v2(125.57,18.7) 125.76,18.89 125.76,20.16 125.37,20.56 125.37,23.3 125.58,23.52 J17.26
KSO_14: length 49.5
  TOP w0.079: U17.K7 v1(156.16,24.67)
  TOP w0.109: v2(123.58,19.09) 124.01,18.67 124.65,18.67 125.68,19.7 D16.2
  IN2 w0.097: v2(123.58,19.09) 124.97,17.7 135.77,17.7 138.05,19.98 145.43,19.98 146.66,21.21 147.4,21.21 147.85,21.66 147.85,22.25 148.19,22.59 149.55,22.59 150.04,23.08 150.04,23.65 150.83,24.44 153.85,24.44 154.03,24.26 155.97,24.26 156.16,24.45 v1(156.16,24.67)
  BOTTOM w0.114: J17.28 123.98,22.36 124.25,22.08 124.25,19.96 123.58,19.29 v2(123.58,19.09) 123.58,18.89 123.28,18.59 122.89,18.59 122.27,17.98 J25.28
LATCH_FB: length 81.9
  TOP w0.109: D28.1 87.32,12.36 87.63,12.06 88.91,12.06 89.2,12.34 Q17.2 89.69,12.34 90.29,12.94 Q19.3 90.62,15.25 v2(90.89,15.53) ; R299.2 41.7,47.56 v2(41.98,47.28)
  IN4 w0.089: v2(90.89,15.53) 90.3,16.12 90.02,16.12 86.5,19.65 83.33,19.65 82.26,18.58 73.89,18.58 69.4,23.07 69.4,26.92 71.18,28.7 71.18,30.78 70.29,31.67 70.29,39.14 68.93,40.49 62.72,40.49 61.46,41.76 50.8,41.76 45.28,47.28 v2(41.98,47.28)
LED_B_ODL: length 164.6
  TOP w0.109: v1(143.73,27.77) 146.33,27.77 146.4,27.84 148.95,27.84 149.19,27.59 U17.A12 ; v2(14.37,18.03) 14.4,18.07 R196.2
  IN2 w0.097: v2(14.37,18.03) 15.68,18.03 22.55,11.16 26.11,11.16 28.85,8.42 50.21,8.42 52.26,10.47 54.25,10.47 59.58,15.8 63.87,15.8 65.17,14.5 77.5,14.5 77.78,14.22 79.51,14.22 80.79,12.94 94.35,12.94 95.13,12.17 104.2,12.17 v2(104.75,12.72) ; v1(143.73,27.77) 143.73,26.9 142.73,25.9 141.69,25.9 140.69,24.9 138.71,24.9 136.47,22.66 134.48,22.66 133.29,21.47 131.81,21.47 130.62,20.28 125.37,20.28 125.07,20.58 125.07,21.17 124.77,21.47 123.78,21.47 123.09,20.77 119.16,20.77 118.07,21.87 107.34,21.87 107.2,22.01 105.21,22.01 v2(104.3,22.92)
  BOTTOM w0.114: v2(104.3,22.92) 105.18,22.04 105.22,22.04 106.61,20.65 107.23,20.65 107.9,19.98 107.9,16.32 104.73,13.14 104.73,12.75 v2(104.75,12.72)
LED_G_ODL: length 164.2
  TOP w0.079: U17.G7 v1(154.21,24.67)
  TOP w0.109: v2(13.77,18.03) 14.2,18.46 15.17,18.46 15.57,18.07 R195.2
  IN2 w0.097: v1(154.21,24.67) 150.5,24.67 148.71,22.87 145.97,22.87 144.6,24.24 142.83,24.24 141.14,22.56 139.13,22.56 136.07,19.49 131.61,19.49 131.21,19.09 124.79,19.09 124.29,19.58 121.6,19.58 120.91,18.89 117.77,18.89 115.79,20.87 108.53,20.87 v2(108.23,20.58) ; v2(13.77,18.03) 14.25,17.55 15.82,17.55 22.45,10.92 26.01,10.92 28.73,8.2 50.48,8.2 52.51,10.23 54.33,10.23 59.66,15.56 63.82,15.56 65.08,14.3 77.33,14.3 77.62,14.01 79.35,14.01 80.64,12.72 83.99,12.72 84.61,12.11 89.09,12.11 89.71,12.72 94.11,12.72 94.87,11.96 105.27,11.96 v2(106.02,12.72)
  BOTTOM w0.114: v2(106.02,12.72) 106.02,13.73 108.4,16.1 108.4,20.41 v2(108.23,20.58)
LED_R_ODL: length 163.9
  TOP w0.109: U17.B12 150.64,27.75 149.75,28.64 147.97,28.64 147.72,28.38 144.34,28.38 v1(144.16,28.21) ; R194.2 16.46,18.26 v2(16.2,18.53)
  IN2 w0.097: v2(105.38,12.72) 104.95,13.16 80.87,13.16 79.58,14.44 77.96,14.44 77.66,14.73 65.23,14.73 63.94,16.02 59.49,16.02 54.14,10.67 52.16,10.67 50.11,8.62 28.97,8.62 26.2,11.39 22.64,11.39 16.2,17.83 v2(16.2,18.53) ; v1(144.16,28.21) 143.54,28.21 143.32,27.98 143.32,26.82 142.61,26.12 141.61,26.12 140.61,25.12 138.65,25.12 136.4,22.87 134.39,22.87 133.19,21.67 131.71,21.67 130.52,20.48 125.47,20.48 125.27,20.68 125.27,21.27 124.87,21.67 123.68,21.67 122.98,20.97 119.27,20.97 118.17,22.06 107.43,22.06 107.27,22.22 105.63,22.22 v2(104.95,22.91)
  BOTTOM w0.114: v2(105.38,12.72) 105.38,13.44 108.15,16.2 108.15,20.08 107.33,20.89 106.8,20.89 104.95,22.74 v2(104.95,22.91)
LID_360_L: length 266.5
  TOP w0.079: v1(154.21,26.62) U17.H10
  TOP w0.109: v2(15.89,65.09) 15.64,64.83 R27330.2
  IN2 w0.097: v2(97.05,85.05) 98.34,86.34 164.51,86.34 169.85,81 176.75,81 188.3,69.45 188.71,69.45 189.45,68.72 v2(189.45,68.57) 188.41,68.57 187.5,67.65 187.5,61 188.17,60.32 188.17,50.89 187.18,49.9 187.18,46.23 186.49,45.54 186.49,43.46 186,42.97 186,40.14 184.21,38.35 184.21,36.52 180.03,32.35 169.79,32.35 169.16,31.72 168.91,31.72 167.71,30.53 167.71,30.27 164.41,26.97 163.96,26.97 162.67,28.26 157.62,28.26 156.67,27.31 154.91,27.31 v1(154.21,26.62) ; v2(62.84,69.81) 62.2,70.46 50.77,70.46 48.52,68.21 40.48,68.21 40.35,68.08 38.23,68.08 37.37,68.95 36.75,68.95 35.24,67.44 33.76,67.44 33.18,66.85 26.64,66.85 23.7,63.92 18,63.92 16.83,65.09 v2(15.89,65.09)
  IN4 w0.089: v2(97.05,85.05) 96.61,85.48 95.73,85.48 93.13,82.89 87.14,82.89 84.12,79.87 77.96,79.87 68.76,70.67 63.71,70.67 v2(62.84,69.81)
  BOTTOM w0.114: R91325.1 190.16,67.67 190.37,67.88 190.37,68.44 190.24,68.57 v2(189.45,68.57)
LID_360_L_GMR: length 2.3
  TOP w0.109: U6582.1 14.05,66.26 14.26,66.05 D2743.1 R27330.1
LID_OPEN: length 367.4
  TOP w0.079: v1(150.73,28.38) 150.73,28.03 150.97,27.8 150.97,27.26 U17.C11
  TOP w0.109: v2(84.28,13.55) 84.53,13.3 C289.1 ; v2(13.66,65.66) 13.48,65.84 R1.1 ; D21.2 171.86,21.58 v1(170.91,22.53)
  IN1 w0.097: v2(84.28,13.55) 85.32,14.59 85.32,15.26 88,17.94 106.27,17.94 106.41,17.8 111.8,17.8 111.89,17.7 115.37,17.7 v2(115.74,18.07)
  IN2 w0.097: v1(170.91,22.53) 170.93,22.55 173.39,22.55 174.22,23.39 175.76,23.39 176.75,24.38 184.78,24.38 190.15,29.76 190.15,51.32 192.19,53.36 192.19,58.99 188.21,62.98 188.21,66.94 189.11,67.84 189.62,67.84 v2(189.91,68.13) 189.91,68.82 188.92,69.81 188.28,69.81 176.89,81.2 169.94,81.2 164.56,86.59 97.93,86.59 v2(96.4,85.05) ; v2(63.49,69.81) 62.63,70.67 50.68,70.67 48.43,68.43 40.39,68.43 40.26,68.3 38.32,68.3 37.46,69.16 36.66,69.16 35.15,67.65 33.67,67.65 33.09,67.07 26.55,67.07 23.61,64.13 18.17,64.13 16.74,65.56 13.76,65.56 v2(13.66,65.66)
  IN4 w0.089: v1(170.91,22.53) 170.54,22.9 169.93,22.9 169.47,22.44 167.45,22.44 167,22.9 163.34,22.9 162.83,23.41 162.83,24.57 162.38,25.03 161.61,25.03 160.36,26.27 160.36,28.19 159.66,28.89 157.37,28.89 156.61,28.13 151.17,28.13 150.91,28.38 v1(150.73,28.38) 150.73,26.73 149.85,25.84 149.85,24.45 149.75,24.35 149.75,24.06 149.2,23.52 148.82,23.52 147.54,22.24 147.16,22.24 146.2,21.27 146.2,20.5 143.79,18.1 136.66,18.1 135.62,19.14 125.42,19.14 124.35,18.07 v2(115.74,18.07) ; v2(63.49,69.81) 64.14,70.46 68.85,70.46 78.05,79.65 84.21,79.65 87.25,82.7 93.22,82.7 95.57,85.05 v2(96.4,85.05)
  BOTTOM w0.114: R91324.1 189.22,67.75 189.6,68.13 v2(189.91,68.13)
LID_OPEN_GMR: length 2.5
  TOP w0.109: U6582.4 13.75,68.27 13.61,68.13 13.61,67.75 13.5,67.64 D2748.1 R1.2
LSPK_LDO: length 1.4
  TOP w0.109: C134.1 23.87,21.72 23.6,22 U2.19
LSPK_N:
  vias: v2(26.37,26.48) v2(26.37,25.84)
LSPK_P: length 8.5
  TOP w1.016: 25.37,27.16 25.37,28.15 25.66,28.45 25.66,29.92 24.87,30.7 21.84,30.7 20.86,29.72 20.86,29.59
  vias: v2(25.06,26.23) v2(25.06,25.59)
LSPK_R_N:
  vias: v4(25.24,23.56)
LSPK_VCM: length 1.3
  TOP w0.109: U2.20 23.17,22.5 23.36,22.31 C133.1
M2_WLAN_32K: length 1.2
  BOTTOM w0.114: R27311.1 32.53,23.08 32.85,22.75 U4100.27
M2_WLAN_RST_L: length 1.2
  BOTTOM w0.114: R27312.2 41.87,24.95 41.85,24.93 U4100.44
M_A_DQ_0_0: length 31.9
  TOP w0.089: U4301.E11 v1(146.95,46.44) ; U1JSL.M28 v1(129.11,61.59)
  IN3 w0.089: 131.46,62.5 131.24,62.5 130.69,61.95 129.47,61.95 v1(129.11,61.59)
  IN3 w0.135: v1(146.95,46.44) 146.45,46.95 146.45,55.54 138.42,63.57 135.35,63.57 134.78,62.99 133.56,62.99 133.06,62.5 131.46,62.5
M_A_DQ_0_1: length 29.7
  TOP w0.089: U1JSL.J28 130.4,61.54 130.43,61.58 v1(130.43,61.59) ; U4301.C11 v1(145.65,46.44)
  IN3 w0.089: 133.48,62.13 133.3,61.95 130.94,61.95 130.58,61.59 v1(130.43,61.59)
  IN3 w0.135: v1(145.65,46.44) 145.94,46.73 145.94,55.58 138.34,63.18 135.45,63.18 134.88,62.61 133.96,62.61 133.48,62.13
M_A_DQ_0_2: length 33.8
  TOP w0.089: U1JSL.P28 v1(128.45,61.59) ; U4301.F11 v1(147.6,46.44)
  IN3 w0.089: v1(128.45,61.59) 128.99,62.13 130.59,62.13 131.28,62.82
  IN3 w0.135: v1(147.6,46.44) 147.97,46.82 147.97,47.77 146.96,48.78 146.96,55.51 138.44,64.02 134.08,64.02 132.99,62.93 131.39,62.93 131.28,62.82
M_A_DQ_0_3: length 29
  TOP w0.089: U4301.B9 v1(145,44.87) ; U1JSL.H30 v1(131.09,60.67)
  IN3 w0.135: v1(131.09,60.67) 131.29,60.47 133.5,60.47 134.38,59.58 134.9,59.58 135.06,59.74 135.06,60.08 135.19,60.22 135.47,60.22 135.6,60.08 135.6,59.76 135.78,59.58 136.54,59.58 138.07,58.05 139.28,58.05 140.06,57.27 140.45,57.27 140.83,56.89 140.83,56.7 140.73,56.6 140.73,56.41 140.92,56.21 141.11,56.21 141.21,56.31 141.4,56.31 141.6,56.12 141.6,55.93 141.5,55.83 141.5,55.64 141.68,55.46 141.89,55.46 141.98,55.55 142.17,55.55 142.36,55.36 142.36,55.17 142.26,55.06 142.26,54.87 142.45,54.68 142.64,54.68 142.75,54.78 142.94,54.78 143.53,54.19 143.53,45.55 143.77,45.3 144.57,45.3 v1(145,44.87)
M_A_DQ_0_4: length 29.7
  TOP w0.089: U1JSL.H28 v1(131.09,61.59) ; U4301.B11 v1(145,46.44)
  IN3 w0.089: v1(131.09,61.59) 131.24,61.74 133.82,61.74
  IN3 w0.135: 133.82,61.74 134.17,62.09 137.84,62.09 140.42,59.51 141.44,59.51 141.63,59.31 141.63,59.12 141.31,58.81 141.31,58.62 141.51,58.42 141.7,58.42 142.01,58.74 142.2,58.74 142.4,58.55 142.4,58.36 142.08,58.04 142.08,57.85 142.27,57.66 142.46,57.66 142.78,57.97 142.97,57.97 143.16,57.78 143.16,57.59 142.85,57.27 142.85,57.08 145,54.93 v1(145,46.44)
M_A_DQ_0_5: length 29.9
  TOP w0.089: U4301.C9 v1(145.65,44.87) ; U1JSL.J30 v1(130.43,60.68)
  IN3 w0.089: v1(130.43,60.68) 130.56,60.68 131.04,60.2 133.19,60.2 133.85,59.55
  IN3 w0.135: 133.85,59.55 134.15,59.25 136.37,59.25 137.94,57.67 138.99,57.67 139.38,57.28 139.38,57.09 139.23,56.95 139.23,56.76 139.43,56.57 139.62,56.57 139.76,56.71 139.95,56.71 140.14,56.52 140.14,56.33 140,56.18 140,55.99 140.19,55.8 140.38,55.8 140.53,55.94 140.72,55.94 140.91,55.75 140.91,55.56 140.77,55.42 140.77,55.23 140.96,55.03 141.15,55.03 141.29,55.18 141.48,55.18 143.19,53.47 143.19,45.41 144.21,44.39 145.17,44.39 v1(145.65,44.87)
M_A_DQ_0_6: length 30.5
  TOP w0.089: U1JSL.M30 v1(129.11,60.68) ; U4301.E9 v1(146.94,44.05)
  IN3 w0.089: v1(129.11,60.68) 129.47,60.32 130.66,60.32 130.96,60.03 132.54,60.03 132.8,59.77
  IN3 w0.135: v1(146.94,44.05) 146.82,44.05 146.37,43.6 145.46,43.6 145.1,43.96 144.16,43.96 142.86,45.26 142.86,52.66 138.53,56.99 137.18,56.99 135.89,58.28 134.28,58.28 132.8,59.77
M_A_DQ_0_7: length 32.2
  TOP w0.089: U1JSL.P30 v1(128.45,60.68) ; U4301.F9 v1(147.59,44.05)
  IN3 w0.089: v1(128.45,60.68) 128.99,60.14 130.58,60.14 130.87,59.85 132.36,59.85 133.07,59.15
  IN3 w0.135: 133.07,59.15 134.36,57.86 135.82,57.86 137.07,56.61 138.43,56.61 142.52,52.52 142.52,45.12 144.07,43.57 144.9,43.57 145.2,43.27 146.41,43.27 146.79,43.65 147.34,43.65 147.59,43.9 v1(147.59,44.05)
M_A_DQ_1_0: length 39.4
  TOP w0.088: U1JSL.E28 132.48,61.28 132.63,61.18 132.8,61.16 132.97,61.2 133.1,61.18 133.21,61.11 133.25,61.07 133.53,61.07 133.6,61.14 134.03,61.14 134.35,60.82 137.36,60.82 v1(137.68,61.15)
  TOP w0.089: U4301.AA11 v1(158,46.44)
  IN5 w0.089: v1(158,46.44) 158,47.09 156.76,48.33 149.93,48.33 145.47,52.79 145.47,53.31 144.72,54.07 144.59,54.07 144.4,53.88 144.28,53.88 144.12,54.03 144.12,54.15 144.31,54.34 144.31,54.47 144.16,54.62 144.03,54.62 143.84,54.43 143.72,54.43 143.57,54.59 143.57,54.71 143.76,54.9 143.76,55.03 143.6,55.18 143.48,55.18 143.29,54.99 143.16,54.99 143.01,55.14 143.01,55.27 143.2,55.46 143.2,55.58 143.04,55.74 142.92,55.74 142.73,55.55 142.6,55.55 142.45,55.7 142.45,55.83 142.64,56.02 142.64,56.14 142.49,56.29 142.36,56.29 142.17,56.1 142.05,56.1 141.89,56.26 141.89,56.38 142.08,56.57 142.08,56.7 141.93,56.85 141.8,56.85 141.61,56.66 141.49,56.66 141.34,56.82 141.34,56.94 141.53,57.13 141.53,57.26 141.37,57.41 141.25,57.41 141.06,57.22 140.93,57.22 140.78,57.37 140.78,57.5 140.97,57.69 140.97,57.81 138.32,60.46 138.2,60.46 137.88,60.14 137.76,60.14 137.6,60.29 137.6,60.42 137.92,60.74 137.92,60.86 137.68,61.1 v1(137.68,61.15)
M_A_DQ_1_1: length 38.5
  TOP w0.088: U1JSL.D28 132.98,61.45 133.29,61.64 133.46,61.64 133.66,61.5 134.18,61.5 134.5,61.18 135.68,61.18 v1(136.06,61.56)
  TOP w0.089: U4301.V11 v1(156.05,46.44)
  IN5 w0.089: v1(136.06,61.56) 136.06,60.08 141.6,54.55 141.72,54.55 142.16,54.98 142.28,54.98 142.43,54.83 142.43,54.7 142,54.27 142,54.14 142.15,53.99 142.28,53.99 142.71,54.42 142.84,54.42 142.99,54.27 142.99,54.14 142.56,53.71 142.56,53.59 142.71,53.43 142.84,53.43 143.27,53.87 143.4,53.87 143.55,53.71 143.55,53.59 143.12,53.15 143.12,53.03 143.27,52.88 143.39,52.88 143.83,53.31 143.95,53.31 144.11,53.16 144.11,53.03 143.67,52.6 143.67,52.47 143.83,52.32 143.95,52.32 144.39,52.75 144.58,52.75 144.9,52.44 144.9,52.11 145.18,51.83 145.51,51.83 149.59,47.75 156.12,47.75 156.46,47.41 156.46,46.85 v1(156.05,46.44)
M_A_DQ_1_2: length 39.8
  TOP w0.088: U1JSL.F27 131.96,61.74 132.79,61.74 132.86,61.71 133.06,61.71 133.24,61.82 133.28,61.82 133.52,61.82 133.69,61.69 133.69,61.69 133.72,61.67 134.63,61.67 v1(134.74,61.56)
  TOP w0.089: U4301.U11 v1(155.4,46.44)
  IN5 w0.089: v1(134.74,61.56) 134.74,60.99 138.17,57.57 138.17,57.44 137.92,57.19 137.92,57.06 138.07,56.91 138.2,56.91 138.45,57.16 138.58,57.16 138.73,57.01 138.73,56.88 138.47,56.63 138.47,56.5 138.63,56.35 138.75,56.35 139.01,56.6 139.13,56.6 139.29,56.45 139.29,56.33 139.03,56.07 139.03,55.95 139.18,55.79 139.31,55.79 139.56,56.05 139.69,56.05 139.84,55.89 139.84,55.77 139.59,55.51 139.59,55.39 139.74,55.23 139.87,55.23 140.12,55.49 140.25,55.49 140.99,54.74 140.99,54.62 140.67,54.3 140.67,54.18 140.83,54.02 140.95,54.02 141.27,54.34 141.4,54.34 141.55,54.19 141.55,54.06 141.23,53.74 141.23,53.62 141.38,53.46 141.51,53.46 141.83,53.78 141.95,53.78 142.11,53.63 142.11,53.5 141.79,53.19 141.79,53.06 141.94,52.91 142.07,52.91 142.39,53.23 142.51,53.23 142.66,53.07 142.66,52.95 142.35,52.63 142.35,52.5 142.5,52.35 142.62,52.35 142.94,52.67 143.07,52.67 143.22,52.52 143.22,52.39 142.9,52.07 142.9,51.95 143.06,51.79 143.18,51.79 143.5,52.11 143.63,52.11 144.2,51.54 145.34,51.54 149.42,47.46 152.6,47.46 153.21,46.85 154.99,46.85 v1(155.4,46.44)
M_A_DQ_1_3: length 39.3
  TOP w0.088: U1JSL.B25 133.35,62.7 134.91,62.7 135.31,63.1 137.24,63.1 137.6,62.74 137.6,62.49 138.78,61.31 v1(139.58,61.31)
  TOP w0.089: U4301.Y9 v1(157.35,44.04)
  IN5 w0.089: v1(157.35,44.04) 157.43,44.04 157.83,44.44 158.73,44.44 159.73,45.44 159.73,47.72 157.44,50.01 150.61,50.01 147.14,53.49 147.14,54.26 140.09,61.31 v1(139.58,61.31)
M_A_DQ_1_4: length 38.2
  TOP w0.088: v1(136.72,61.56) 136.16,61 134.43,61 134.11,61.32 133.41,61.32 U1JSL.B28
  TOP w0.089: U4301.Y11 v1(157.35,46.44)
  IN5 w0.089: v1(157.35,46.44) 156.94,46.86 156.94,47.74 156.64,48.04 149.71,48.04 142.01,55.73 141.88,55.73 141.41,55.27 141.29,55.27 141.14,55.42 141.14,55.54 141.6,56.01 141.6,56.14 141.45,56.29 141.33,56.29 140.86,55.82 140.73,55.82 140.58,55.98 140.58,56.1 141.05,56.57 141.05,56.7 140.83,56.91 140.62,56.91 140.19,56.49 140.07,56.49 139.92,56.64 139.92,56.76 140.23,57.08 140.23,57.21 140.08,57.36 139.95,57.36 139.64,57.04 139.51,57.04 139.36,57.2 139.36,57.32 139.66,57.62 139.66,57.75 139.5,57.9 139.38,57.9 139.08,57.6 138.95,57.6 138.8,57.75 138.8,57.88 139.05,58.13 139.05,58.26 136.72,60.59 v1(136.72,61.56)
M_A_DQ_1_5: length 40.7
  TOP w0.088: U1JSL.D25 132.92,62.54 133.09,62.45 133.26,62.37 133.4,62.38 133.62,62.53 134.99,62.53 135.38,62.92 137.17,62.92 137.42,62.67 137.42,62.42 v4(139.46,60.38) v1(140.51,60.38)
  TOP w0.089: U4301.U9 v1(155.4,44.84)
  IN5 w0.089: v1(140.51,60.38) 146.85,54.04 146.85,53.37 150.49,49.73 157.32,49.73 159.41,47.63 159.41,46.08 158.6,45.28 158.29,45.28 157.44,44.43 155.81,44.43 v1(155.4,44.84)
M_A_DQ_1_6: length 43.8
  TOP w0.088: U1JSL.E25 132.58,62.98 132.61,63.01 132.99,63.01 133.18,63.13 133.63,63.13 133.7,63.06 134.77,63.06 135.21,63.51 137.69,63.51 138.18,63.02 v1(138.18,62.71)
  TOP w0.089: U4301.V9 v1(156.05,44.04)
  IN5 w0.089: v1(156.05,44.04) 156.46,43.63 158.73,43.63 160.3,45.2 160.3,47.96 157.68,50.59 150.85,50.59 147.72,53.73 147.72,54.5 139.51,62.71 v1(138.18,62.71)
M_A_DQ_1_7: length 41.4
  TOP w0.088: v1(139.11,61.78) 138.56,61.78 137.78,62.56 137.78,62.82 137.29,63.3 135.26,63.3 134.84,62.88 133.62,62.88 133.55,62.95 133.23,62.95 133.04,62.83 132.69,62.83 132.68,62.83 132.68,62.82 132.65,62.81 132.56,62.77 132.34,62.55 132.1,62.55 131.92,62.73 U1JSL.F25
  TOP w0.089: U4301.AA9 v1(158,44.04)
  IN5 w0.089: v1(158,44.04) 158.74,44.04 160.01,45.32 160.01,47.84 157.56,50.3 150.73,50.3 147.43,53.61 147.43,54.38 140.03,61.78 v1(139.11,61.78)
M_A_DQ_2_0: length 32
  TOP w0.089: U4301.E4 v1(146.94,40.84) ; U1JSL.M34 v1(129.11,58.88)
  IN3 w0.089: v1(129.11,58.88) 129.47,59.24 130.69,59.24 130.89,59.44 132.16,59.44 132.37,59.24 133,58.61 133,58.18
  IN3 w0.135: v1(146.94,40.84) 146.94,40.84 147.47,41.36 147.47,41.82 146.96,42.32 144,42.32 141.1,45.22 141.1,51.06 135.71,56.45 134.51,56.45 133,57.96 133,58.18
M_A_DQ_2_1: length 28.9
  TOP w0.089: U1JSL.J34 v1(130.43,58.88) ; U4301.C4 v1(145.64,40.84)
  IN3 w0.089: 132.85,57.79 132.72,57.91 132.72,58.63 132.11,59.24 130.94,59.24 130.58,58.88 v1(130.43,58.88)
  IN3 w0.135: 132.85,57.79 134.55,56.08 134.68,56.08 136.73,54.04 137.22,54.04 139.04,52.22 139.04,52.03 138.68,51.67 138.68,51.48 138.86,51.3 139.08,51.3 139.42,51.65 139.61,51.65 140.77,50.49 140.77,45.08 144.59,41.26 145.22,41.26 v1(145.64,40.84)
M_A_DQ_2_2: length 33.1
  TOP w0.089: U4301.F4 v1(147.59,40.84) ; U1JSL.P34 v1(128.45,58.88)
  IN3 w0.089: v1(128.45,58.88) 128.45,59.16 128.71,59.42 130.61,59.42 130.81,59.62 132.24,59.62 133.18,58.68 133.18,58.5 133.3,58.37
  IN3 w0.135: 133.3,58.37 134.28,57.39 135.6,57.39 136.66,56.34 136.66,56 141.75,50.9 141.75,45.04 144.16,42.63 147.11,42.63 147.72,42.02 147.72,40.97 v1(147.59,40.84)
M_A_DQ_2_3: length 28.6
  TOP w0.089: U1JSL.H36 v1(131.09,57.98) ; U4301.E2 v1(146.96,38.44)
  IN3 w0.135: v1(146.96,38.44) 146.57,38.83 146.09,38.83 145.28,39.64 144.64,39.64 144.43,39.42 143.87,39.42 138.69,44.6 138.69,48.21 134.16,52.74 134.16,53.79 132.89,55.06 132.89,56.18 v1(131.09,57.98)
M_A_DQ_2_4: length 28.9
  TOP w0.089: U1JSL.H34 v1(131.09,58.88) ; U4301.B4 v1(144.99,40.84)
  IN3 w0.135: v1(144.99,40.84) 144.52,40.84 144.52,40.86 140.44,44.94 140.44,48.55 139.99,48.99 139.99,49.18 140.39,49.57 140.39,49.76 140.2,49.95 140.01,49.95 139.61,49.56 139.42,49.56 139.23,49.75 139.23,49.94 139.62,50.34 139.62,50.53 139.43,50.72 139.24,50.72 138.85,50.33 138.66,50.33 138.35,50.64 138.35,52.44 137.21,53.57 136.38,53.57 136.04,53.91 136.04,54.24 135.4,54.88 134.78,54.88 134.52,55.14 134.52,55.76 131.4,58.88 v1(131.09,58.88)
